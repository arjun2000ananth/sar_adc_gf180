v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 410 -1330 410 -1300 {
lab=vss}
N 230 -1420 260 -1420 {
lab=sample}
N 230 -1400 260 -1400 {
lab=sampleb}
N 410 -1480 410 -1450 {
lab=vdda}
N 230 -1370 260 -1370 {
lab=ainp}
N 560 -1390 590 -1390 {
lab=vcp}
N 410 -1050 410 -1020 {
lab=vss}
N 230 -1140 260 -1140 {
lab=sample}
N 230 -1120 260 -1120 {
lab=sampleb}
N 410 -1200 410 -1170 {
lab=vdda}
N 230 -1090 260 -1090 {
lab=ainn}
N 560 -1110 590 -1110 {
lab=vcn}
N 810 -1330 810 -1300 {
lab=vdda}
N 630 -1250 660 -1250 {
lab=sample}
N 960 -1250 990 -1250 {
lab=sampleb}
N 810 -1200 810 -1170 {
lab=vss}
N 410 -580 410 -550 {
lab=vss}
N 230 -670 260 -670 {
lab=rstf}
N 230 -650 260 -650 {
lab=rstfb}
N 410 -730 410 -700 {
lab=vdda}
N 230 -620 260 -620 {
lab=vcm}
N 560 -640 590 -640 {
lab=vfp}
N 410 -300 410 -270 {
lab=vss}
N 230 -390 260 -390 {
lab=rstf}
N 230 -370 260 -370 {
lab=rstfb}
N 410 -450 410 -420 {
lab=vdda}
N 230 -340 260 -340 {
lab=vcm}
N 560 -360 590 -360 {
lab=vfn}
N 810 -580 810 -550 {
lab=vdda}
N 630 -500 660 -500 {
lab=rstf}
N 960 -500 990 -500 {
lab=rstfb}
N 810 -450 810 -420 {
lab=vss}
N 1590 -1700 1620 -1700 {
lab=vcp}
N 1590 -1680 1620 -1680 {
lab=vfp}
N 1590 -1660 1620 -1660 {
lab=bp9}
N 1590 -1640 1620 -1640 {
lab=bp8}
N 1590 -1620 1620 -1620 {
lab=bp7}
N 1590 -1600 1620 -1600 {
lab=bp6}
N 1590 -1580 1620 -1580 {
lab=bp5}
N 1590 -1560 1620 -1560 {
lab=bpr}
N 1590 -1540 1620 -1540 {
lab=bp4}
N 1590 -1520 1620 -1520 {
lab=bp3}
N 1590 -1500 1620 -1500 {
lab=bp2}
N 1590 -1480 1620 -1480 {
lab=bp1}
N 1590 -1460 1620 -1460 {
lab=bp0}
N 1590 -1440 1620 -1440 {
lab=vcm}
N 1260 -1700 1290 -1700 {
lab=vcn}
N 1260 -1680 1290 -1680 {
lab=vfn}
N 1260 -1660 1290 -1660 {
lab=bn9}
N 1260 -1640 1290 -1640 {
lab=bn8}
N 1260 -1620 1290 -1620 {
lab=bn7}
N 1260 -1600 1290 -1600 {
lab=bn6}
N 1260 -1580 1290 -1580 {
lab=bn5}
N 1260 -1560 1290 -1560 {
lab=bnr}
N 1260 -1540 1290 -1540 {
lab=bn4}
N 1260 -1520 1290 -1520 {
lab=bn3}
N 1260 -1500 1290 -1500 {
lab=bn2}
N 1260 -1480 1290 -1480 {
lab=bn1}
N 1260 -1460 1290 -1460 {
lab=bn0}
N 1260 -1440 1290 -1440 {
lab=vcm}
N 1610 -980 1640 -980 {
lab=compb}
N 1280 -980 1310 -980 {
lab=vcn}
N 1610 -940 1640 -940 {
lab=comp}
N 1280 -960 1310 -960 {
lab=vcp}
N 1460 -1050 1460 -1020 {
lab=vdda}
N 1460 -900 1460 -870 {
lab=vss}
N 1280 -940 1310 -940 {
lab=comp_clk}
N 500 -2470 530 -2470 {
lab=dbp9}
N 830 -2510 860 -2510 {
lab=bp9}
N 680 -2400 680 -2370 {
lab=vss}
N 680 -2570 680 -2540 {
lab=vdda}
N 830 -2480 860 -2480 {
lab=vrefp}
N 830 -2450 860 -2450 {
lab=vcm}
N 1060 -2470 1090 -2470 {
lab=dbp8}
N 1390 -2510 1420 -2510 {
lab=bp8}
N 1240 -2400 1240 -2370 {
lab=vss}
N 1240 -2570 1240 -2540 {
lab=vdda}
N 1390 -2480 1420 -2480 {
lab=vrefp}
N 1390 -2450 1420 -2450 {
lab=vcm}
N 510 -2160 540 -2160 {
lab=dbp7}
N 840 -2200 870 -2200 {
lab=bp7}
N 690 -2090 690 -2060 {
lab=vss}
N 690 -2260 690 -2230 {
lab=vdda}
N 840 -2170 870 -2170 {
lab=vrefp}
N 840 -2140 870 -2140 {
lab=vcm}
N 1070 -2160 1100 -2160 {
lab=dbp6}
N 1400 -2200 1430 -2200 {
lab=bp6}
N 1250 -2090 1250 -2060 {
lab=vss}
N 1250 -2260 1250 -2230 {
lab=vdda}
N 1400 -2170 1430 -2170 {
lab=vrefp}
N 1400 -2140 1430 -2140 {
lab=vcm}
N 2770 -2510 2800 -2510 {
lab=dbp5}
N 3100 -2550 3130 -2550 {
lab=bp5}
N 2950 -2440 2950 -2410 {
lab=vss}
N 2950 -2610 2950 -2580 {
lab=vdda}
N 3100 -2520 3130 -2520 {
lab=vrefp}
N 3100 -2490 3130 -2490 {
lab=vcm}
N 3330 -2510 3360 -2510 {
lab=dbpr}
N 3660 -2550 3690 -2550 {
lab=bpr}
N 3510 -2440 3510 -2410 {
lab=vss}
N 3510 -2610 3510 -2580 {
lab=vdda}
N 3660 -2520 3690 -2520 {
lab=vrefp}
N 3660 -2490 3690 -2490 {
lab=vcm}
N 2770 -2130 2800 -2130 {
lab=dbp4}
N 3100 -2170 3130 -2170 {
lab=bp4}
N 2950 -2060 2950 -2030 {
lab=vss}
N 2950 -2230 2950 -2200 {
lab=vdda}
N 3100 -2140 3130 -2140 {
lab=vrefp}
N 3100 -2110 3130 -2110 {
lab=vcm}
N 3330 -2130 3360 -2130 {
lab=dbp3}
N 3660 -2170 3690 -2170 {
lab=bp3}
N 3510 -2060 3510 -2030 {
lab=vss}
N 3510 -2230 3510 -2200 {
lab=vdda}
N 3660 -2140 3690 -2140 {
lab=vrefp}
N 3660 -2110 3690 -2110 {
lab=vcm}
N 2770 -1790 2800 -1790 {
lab=dbp2}
N 3100 -1830 3130 -1830 {
lab=bp2}
N 2950 -1720 2950 -1690 {
lab=vss}
N 2950 -1890 2950 -1860 {
lab=vdda}
N 3100 -1800 3130 -1800 {
lab=vrefp}
N 3100 -1770 3130 -1770 {
lab=vcm}
N 3330 -1790 3360 -1790 {
lab=dbp1}
N 3660 -1830 3690 -1830 {
lab=bp1}
N 3510 -1720 3510 -1690 {
lab=vss}
N 3510 -1890 3510 -1860 {
lab=vdda}
N 3660 -1800 3690 -1800 {
lab=vrefp}
N 3660 -1770 3690 -1770 {
lab=vcm}
N 2790 -1450 2820 -1450 {
lab=dbp0}
N 3120 -1490 3150 -1490 {
lab=bp0}
N 2970 -1380 2970 -1350 {
lab=vss}
N 2970 -1550 2970 -1520 {
lab=vdda}
N 3120 -1460 3150 -1460 {
lab=vrefp}
N 3120 -1430 3150 -1430 {
lab=vcm}
N 1650 -2470 1680 -2470 {
lab=dbn9}
N 1980 -2510 2010 -2510 {
lab=bn9}
N 1830 -2400 1830 -2370 {
lab=vss}
N 1830 -2570 1830 -2540 {
lab=vdda}
N 1980 -2480 2010 -2480 {
lab=vrefp}
N 1980 -2450 2010 -2450 {
lab=vcm}
N 2210 -2470 2240 -2470 {
lab=dbn8}
N 2540 -2510 2570 -2510 {
lab=bn8}
N 2390 -2400 2390 -2370 {
lab=vss}
N 2390 -2570 2390 -2540 {
lab=vdda}
N 2540 -2480 2570 -2480 {
lab=vrefp}
N 2540 -2450 2570 -2450 {
lab=vcm}
N 1660 -2160 1690 -2160 {
lab=dbn7}
N 1990 -2200 2020 -2200 {
lab=bn7}
N 1840 -2090 1840 -2060 {
lab=vss}
N 1840 -2260 1840 -2230 {
lab=vdda}
N 1990 -2170 2020 -2170 {
lab=vrefp}
N 1990 -2140 2020 -2140 {
lab=vcm}
N 2220 -2160 2250 -2160 {
lab=dbn6}
N 2550 -2200 2580 -2200 {
lab=bn6}
N 2400 -2090 2400 -2060 {
lab=vss}
N 2400 -2260 2400 -2230 {
lab=vdda}
N 2550 -2170 2580 -2170 {
lab=vrefp}
N 2550 -2140 2580 -2140 {
lab=vcm}
N 3920 -2510 3950 -2510 {
lab=dbn5}
N 4250 -2550 4280 -2550 {
lab=bn5}
N 4100 -2440 4100 -2410 {
lab=vss}
N 4100 -2610 4100 -2580 {
lab=vdda}
N 4250 -2520 4280 -2520 {
lab=vrefp}
N 4250 -2490 4280 -2490 {
lab=vcm}
N 4480 -2510 4510 -2510 {
lab=dbnr}
N 4810 -2550 4840 -2550 {
lab=bnr}
N 4660 -2440 4660 -2410 {
lab=vss}
N 4660 -2610 4660 -2580 {
lab=vdda}
N 4810 -2520 4840 -2520 {
lab=vrefp}
N 4810 -2490 4840 -2490 {
lab=vcm}
N 3920 -2130 3950 -2130 {
lab=dbn4}
N 4250 -2170 4280 -2170 {
lab=bn4}
N 4100 -2060 4100 -2030 {
lab=vss}
N 4100 -2230 4100 -2200 {
lab=vdda}
N 4250 -2140 4280 -2140 {
lab=vrefp}
N 4250 -2110 4280 -2110 {
lab=vcm}
N 4480 -2130 4510 -2130 {
lab=dbn3}
N 4810 -2170 4840 -2170 {
lab=bn3}
N 4660 -2060 4660 -2030 {
lab=vss}
N 4660 -2230 4660 -2200 {
lab=vdda}
N 4810 -2140 4840 -2140 {
lab=vrefp}
N 4810 -2110 4840 -2110 {
lab=vcm}
N 3920 -1790 3950 -1790 {
lab=dbn2}
N 4250 -1830 4280 -1830 {
lab=bn2}
N 4100 -1720 4100 -1690 {
lab=vss}
N 4100 -1890 4100 -1860 {
lab=vdda}
N 4250 -1800 4280 -1800 {
lab=vrefp}
N 4250 -1770 4280 -1770 {
lab=vcm}
N 4480 -1790 4510 -1790 {
lab=dbn1}
N 4810 -1830 4840 -1830 {
lab=bn1}
N 4660 -1720 4660 -1690 {
lab=vss}
N 4660 -1890 4660 -1860 {
lab=vdda}
N 4810 -1800 4840 -1800 {
lab=vrefp}
N 4810 -1770 4840 -1770 {
lab=vcm}
N 3940 -1450 3970 -1450 {
lab=dbn0}
N 4270 -1490 4300 -1490 {
lab=bn0}
N 4120 -1380 4120 -1350 {
lab=vss}
N 4120 -1550 4120 -1520 {
lab=vdda}
N 4270 -1460 4300 -1460 {
lab=vrefp}
N 4270 -1430 4300 -1430 {
lab=vcm}
N 2070 -1270 2110 -1270 {
lab=vddd}
N 2070 -1250 2110 -1250 {
lab=vss}
N 2070 -1210 2110 -1210 {
lab=clk}
N 2070 -1190 2110 -1190 {
lab=rst_n}
N 2070 -1170 2110 -1170 {
lab=start}
N 2070 -1150 2110 -1150 {
lab=comp}
N 2070 -1130 2110 -1130 {
lab=cal_en}
N 2070 -1110 2110 -1110 {
lab=cal_we}
N 2070 -1090 2110 -1090 {
lab=cal_addr3}
N 2070 -1070 2110 -1070 {
lab=cal_addr2}
N 2070 -1050 2110 -1050 {
lab=cal_addr1}
N 2070 -1030 2110 -1030 {
lab=cal_addr0}
N 2070 -1010 2110 -1010 {
lab=cal_wdata17}
N 2070 -990 2110 -990 {
lab=cal_wdata16}
N 2070 -970 2110 -970 {
lab=cal_wdata15}
N 2070 -950 2110 -950 {
lab=cal_wdata14}
N 2070 -930 2110 -930 {
lab=cal_wdata13}
N 2070 -910 2110 -910 {
lab=cal_wdata12}
N 2070 -890 2110 -890 {
lab=cal_wdata11}
N 2070 -870 2110 -870 {
lab=cal_wdata10}
N 2070 -850 2110 -850 {
lab=cal_wdata9}
N 2070 -830 2110 -830 {
lab=cal_wdata8}
N 2070 -810 2110 -810 {
lab=cal_wdata7}
N 2070 -790 2110 -790 {
lab=cal_wdata6}
N 2070 -770 2110 -770 {
lab=cal_wdata5}
N 2070 -750 2110 -750 {
lab=cal_wdata4}
N 2070 -730 2110 -730 {
lab=cal_wdata3}
N 2070 -710 2110 -710 {
lab=cal_wdata2}
N 2070 -690 2110 -690 {
lab=cal_wdata1}
N 2070 -670 2110 -670 {
lab=cal_wdata0}
N 2510 -1270 2550 -1270 {
lab=sample}
N 2510 -1250 2550 -1250 {
lab=rstf}
N 2510 -1230 2550 -1230 {
lab=comp_clk}
N 2510 -1210 2550 -1210 {
lab=busy}
N 2510 -1190 2550 -1190 {
lab=valid}
N 2510 -1170 2550 -1170 {
lab=raw_stb}
N 2510 -1150 2550 -1150 {
lab=sat}
N 2510 -1130 2550 -1130 {
lab=dbp9}
N 2510 -1110 2550 -1110 {
lab=dbp8}
N 2510 -1090 2550 -1090 {
lab=dbp7}
N 2510 -1070 2550 -1070 {
lab=dbp6}
N 2510 -1050 2550 -1050 {
lab=dbp5}
N 2510 -1030 2550 -1030 {
lab=dbpr}
N 2510 -1010 2550 -1010 {
lab=dbp4}
N 2510 -990 2550 -990 {
lab=dbp3}
N 2510 -970 2550 -970 {
lab=dbp2}
N 2510 -950 2550 -950 {
lab=dbp1}
N 2510 -930 2550 -930 {
lab=dbp0}
N 2510 -910 2550 -910 {
lab=dbn9}
N 2510 -890 2550 -890 {
lab=dbn8}
N 2510 -870 2550 -870 {
lab=dbn7}
N 2510 -850 2550 -850 {
lab=dbn6}
N 2510 -830 2550 -830 {
lab=dbn5}
N 2510 -810 2550 -810 {
lab=dbnr}
N 2510 -790 2550 -790 {
lab=dbn4}
N 2510 -770 2550 -770 {
lab=dbn3}
N 2510 -750 2550 -750 {
lab=dbn2}
N 2510 -730 2550 -730 {
lab=dbn1}
N 2510 -710 2550 -710 {
lab=dbn0}
N 2510 -690 2550 -690 {
lab=code9}
N 2510 -670 2550 -670 {
lab=code8}
N 2510 -650 2550 -650 {
lab=code7}
N 2510 -630 2550 -630 {
lab=code6}
N 2510 -610 2550 -610 {
lab=code5}
N 2510 -590 2550 -590 {
lab=code4}
N 2510 -570 2550 -570 {
lab=code3}
N 2510 -550 2550 -550 {
lab=code2}
N 2510 -530 2550 -530 {
lab=code1}
N 2510 -510 2550 -510 {
lab=code0}
N 2510 -490 2550 -490 {
lab=raw11}
N 2510 -470 2550 -470 {
lab=raw10}
N 2510 -450 2550 -450 {
lab=raw9}
N 2510 -430 2550 -430 {
lab=raw8}
N 2510 -410 2550 -410 {
lab=raw7}
N 2510 -390 2550 -390 {
lab=raw6}
N 2510 -370 2550 -370 {
lab=raw5}
N 2510 -350 2550 -350 {
lab=raw4}
N 2510 -330 2550 -330 {
lab=raw3}
N 2510 -310 2550 -310 {
lab=raw2}
N 2510 -290 2550 -290 {
lab=raw1}
N 2510 -270 2550 -270 {
lab=raw0}
C {iopin.sym} 80 -2380 0 0 {name=io1 lab=vdda}
C {iopin.sym} 80 -2340 0 0 {name=io2 lab=vddd}
C {iopin.sym} 80 -2420 0 0 {name=io3 lab=vss}
C {ipin.sym} 140 -2260 0 0 {name=io4 lab=ainp}
C {ipin.sym} 140 -2238 0 0 {name=io5 lab=ainn}
C {ipin.sym} 140 -2216 0 0 {name=io6 lab=vcm}
C {ipin.sym} 140 -2194 0 0 {name=io7 lab=vrefp}
C {ipin.sym} 140 -2172 0 0 {name=io8 lab=clk}
C {ipin.sym} 140 -2150 0 0 {name=io9 lab=rst_n}
C {ipin.sym} 140 -2128 0 0 {name=io10 lab=start}
C {ipin.sym} 140 -2106 0 0 {name=io11 lab=cal_en}
C {ipin.sym} 140 -2084 0 0 {name=io12 lab=cal_we}
C {ipin.sym} 140 -2062 0 0 {name=io13 lab=cal_addr3}
C {ipin.sym} 140 -2040 0 0 {name=io14 lab=cal_addr2}
C {ipin.sym} 140 -2018 0 0 {name=io15 lab=cal_addr1}
C {ipin.sym} 140 -1996 0 0 {name=io16 lab=cal_addr0}
C {ipin.sym} 140 -1974 0 0 {name=io17 lab=cal_wdata17}
C {ipin.sym} 140 -1952 0 0 {name=io18 lab=cal_wdata16}
C {ipin.sym} 140 -1930 0 0 {name=io19 lab=cal_wdata15}
C {ipin.sym} 140 -1908 0 0 {name=io20 lab=cal_wdata14}
C {ipin.sym} 140 -1886 0 0 {name=io21 lab=cal_wdata13}
C {ipin.sym} 140 -1864 0 0 {name=io22 lab=cal_wdata12}
C {ipin.sym} 140 -1842 0 0 {name=io23 lab=cal_wdata11}
C {ipin.sym} 140 -1820 0 0 {name=io24 lab=cal_wdata10}
C {ipin.sym} 140 -1798 0 0 {name=io25 lab=cal_wdata9}
C {ipin.sym} 140 -1776 0 0 {name=io26 lab=cal_wdata8}
C {ipin.sym} 140 -1754 0 0 {name=io27 lab=cal_wdata7}
C {ipin.sym} 140 -1732 0 0 {name=io28 lab=cal_wdata6}
C {ipin.sym} 140 -1710 0 0 {name=io29 lab=cal_wdata5}
C {ipin.sym} 140 -1688 0 0 {name=io30 lab=cal_wdata4}
C {ipin.sym} 140 -1666 0 0 {name=io31 lab=cal_wdata3}
C {ipin.sym} 140 -1644 0 0 {name=io32 lab=cal_wdata2}
C {ipin.sym} 140 -1622 0 0 {name=io33 lab=cal_wdata1}
C {ipin.sym} 140 -1600 0 0 {name=io34 lab=cal_wdata0}
C {opin.sym} 240 -2260 0 0 {name=io35 lab=busy}
C {opin.sym} 240 -2238 0 0 {name=io36 lab=valid}
C {opin.sym} 240 -2216 0 0 {name=io37 lab=sat}
C {opin.sym} 240 -2194 0 0 {name=io38 lab=raw_stb}
C {opin.sym} 240 -2172 0 0 {name=io39 lab=code9}
C {opin.sym} 240 -2150 0 0 {name=io40 lab=code8}
C {opin.sym} 240 -2128 0 0 {name=io41 lab=code7}
C {opin.sym} 240 -2106 0 0 {name=io42 lab=code6}
C {opin.sym} 240 -2084 0 0 {name=io43 lab=code5}
C {opin.sym} 240 -2062 0 0 {name=io44 lab=code4}
C {opin.sym} 240 -2040 0 0 {name=io45 lab=code3}
C {opin.sym} 240 -2018 0 0 {name=io46 lab=code2}
C {opin.sym} 240 -1996 0 0 {name=io47 lab=code1}
C {opin.sym} 240 -1974 0 0 {name=io48 lab=code0}
C {opin.sym} 240 -1952 0 0 {name=io49 lab=raw11}
C {opin.sym} 240 -1930 0 0 {name=io50 lab=raw10}
C {opin.sym} 240 -1908 0 0 {name=io51 lab=raw9}
C {opin.sym} 240 -1886 0 0 {name=io52 lab=raw8}
C {opin.sym} 240 -1864 0 0 {name=io53 lab=raw7}
C {opin.sym} 240 -1842 0 0 {name=io54 lab=raw6}
C {opin.sym} 240 -1820 0 0 {name=io55 lab=raw5}
C {opin.sym} 240 -1798 0 0 {name=io56 lab=raw4}
C {opin.sym} 240 -1776 0 0 {name=io57 lab=raw3}
C {opin.sym} 240 -1754 0 0 {name=io58 lab=raw2}
C {opin.sym} 240 -1732 0 0 {name=io59 lab=raw1}
C {opin.sym} 240 -1710 0 0 {name=io60 lab=raw0}
C {tg_param.sym} 410 -1390 0 0 {name=xtg_sp WN=2u WP=6u LCH=0.28u}
C {lab_pin.sym} 410 -1300 3 0 {name=p61 sig_type=std_logic lab=vss}
C {lab_pin.sym} 230 -1420 0 0 {name=p62 sig_type=std_logic lab=sample}
C {lab_pin.sym} 230 -1400 0 0 {name=p63 sig_type=std_logic lab=sampleb}
C {lab_pin.sym} 410 -1480 1 0 {name=p64 sig_type=std_logic lab=vdda}
C {lab_pin.sym} 230 -1370 0 0 {name=p65 sig_type=std_logic lab=ainp}
C {lab_pin.sym} 590 -1390 2 0 {name=p66 sig_type=std_logic lab=vcp}
C {tg_param.sym} 410 -1110 0 0 {name=xtg_sn WN=2u WP=6u LCH=0.28u}
C {lab_pin.sym} 410 -1020 3 0 {name=p67 sig_type=std_logic lab=vss}
C {lab_pin.sym} 230 -1140 0 0 {name=p68 sig_type=std_logic lab=sample}
C {lab_pin.sym} 230 -1120 0 0 {name=p69 sig_type=std_logic lab=sampleb}
C {lab_pin.sym} 410 -1200 1 0 {name=p70 sig_type=std_logic lab=vdda}
C {lab_pin.sym} 230 -1090 0 0 {name=p71 sig_type=std_logic lab=ainn}
C {lab_pin.sym} 590 -1110 2 0 {name=p72 sig_type=std_logic lab=vcn}
C {inverter.sym} 810 -1250 0 0 {name=xinv_s}
C {lab_pin.sym} 810 -1330 1 0 {name=p73 sig_type=std_logic lab=vdda}
C {lab_pin.sym} 630 -1250 0 0 {name=p74 sig_type=std_logic lab=sample}
C {lab_pin.sym} 990 -1250 2 0 {name=p75 sig_type=std_logic lab=sampleb}
C {lab_pin.sym} 810 -1170 3 0 {name=p76 sig_type=std_logic lab=vss}
C {tg_param.sym} 410 -640 0 0 {name=xtg_rp WN=1u WP=3u LCH=0.28u}
C {lab_pin.sym} 410 -550 3 0 {name=p77 sig_type=std_logic lab=vss}
C {lab_pin.sym} 230 -670 0 0 {name=p78 sig_type=std_logic lab=rstf}
C {lab_pin.sym} 230 -650 0 0 {name=p79 sig_type=std_logic lab=rstfb}
C {lab_pin.sym} 410 -730 1 0 {name=p80 sig_type=std_logic lab=vdda}
C {lab_pin.sym} 230 -620 0 0 {name=p81 sig_type=std_logic lab=vcm}
C {lab_pin.sym} 590 -640 2 0 {name=p82 sig_type=std_logic lab=vfp}
C {tg_param.sym} 410 -360 0 0 {name=xtg_rn WN=1u WP=3u LCH=0.28u}
C {lab_pin.sym} 410 -270 3 0 {name=p83 sig_type=std_logic lab=vss}
C {lab_pin.sym} 230 -390 0 0 {name=p84 sig_type=std_logic lab=rstf}
C {lab_pin.sym} 230 -370 0 0 {name=p85 sig_type=std_logic lab=rstfb}
C {lab_pin.sym} 410 -450 1 0 {name=p86 sig_type=std_logic lab=vdda}
C {lab_pin.sym} 230 -340 0 0 {name=p87 sig_type=std_logic lab=vcm}
C {lab_pin.sym} 590 -360 2 0 {name=p88 sig_type=std_logic lab=vfn}
C {inverter.sym} 810 -500 0 0 {name=xinv_r}
C {lab_pin.sym} 810 -580 1 0 {name=p89 sig_type=std_logic lab=vdda}
C {lab_pin.sym} 630 -500 0 0 {name=p90 sig_type=std_logic lab=rstf}
C {lab_pin.sym} 990 -500 2 0 {name=p91 sig_type=std_logic lab=rstfb}
C {lab_pin.sym} 810 -420 3 0 {name=p92 sig_type=std_logic lab=vss}
C {cdac_caps_10b_diff_split_cal.sym} 1440 -1560 0 0 {name=xcdac}
C {lab_pin.sym} 1620 -1700 2 0 {name=p93 sig_type=std_logic lab=vcp}
C {lab_pin.sym} 1620 -1680 2 0 {name=p94 sig_type=std_logic lab=vfp}
C {lab_pin.sym} 1620 -1660 2 0 {name=p95 sig_type=std_logic lab=bp9}
C {lab_pin.sym} 1620 -1640 2 0 {name=p96 sig_type=std_logic lab=bp8}
C {lab_pin.sym} 1620 -1620 2 0 {name=p97 sig_type=std_logic lab=bp7}
C {lab_pin.sym} 1620 -1600 2 0 {name=p98 sig_type=std_logic lab=bp6}
C {lab_pin.sym} 1620 -1580 2 0 {name=p99 sig_type=std_logic lab=bp5}
C {lab_pin.sym} 1620 -1560 2 0 {name=p100 sig_type=std_logic lab=bpr}
C {lab_pin.sym} 1620 -1540 2 0 {name=p101 sig_type=std_logic lab=bp4}
C {lab_pin.sym} 1620 -1520 2 0 {name=p102 sig_type=std_logic lab=bp3}
C {lab_pin.sym} 1620 -1500 2 0 {name=p103 sig_type=std_logic lab=bp2}
C {lab_pin.sym} 1620 -1480 2 0 {name=p104 sig_type=std_logic lab=bp1}
C {lab_pin.sym} 1620 -1460 2 0 {name=p105 sig_type=std_logic lab=bp0}
C {lab_pin.sym} 1620 -1440 2 0 {name=p106 sig_type=std_logic lab=vcm}
C {lab_pin.sym} 1260 -1700 0 0 {name=p107 sig_type=std_logic lab=vcn}
C {lab_pin.sym} 1260 -1680 0 0 {name=p108 sig_type=std_logic lab=vfn}
C {lab_pin.sym} 1260 -1660 0 0 {name=p109 sig_type=std_logic lab=bn9}
C {lab_pin.sym} 1260 -1640 0 0 {name=p110 sig_type=std_logic lab=bn8}
C {lab_pin.sym} 1260 -1620 0 0 {name=p111 sig_type=std_logic lab=bn7}
C {lab_pin.sym} 1260 -1600 0 0 {name=p112 sig_type=std_logic lab=bn6}
C {lab_pin.sym} 1260 -1580 0 0 {name=p113 sig_type=std_logic lab=bn5}
C {lab_pin.sym} 1260 -1560 0 0 {name=p114 sig_type=std_logic lab=bnr}
C {lab_pin.sym} 1260 -1540 0 0 {name=p115 sig_type=std_logic lab=bn4}
C {lab_pin.sym} 1260 -1520 0 0 {name=p116 sig_type=std_logic lab=bn3}
C {lab_pin.sym} 1260 -1500 0 0 {name=p117 sig_type=std_logic lab=bn2}
C {lab_pin.sym} 1260 -1480 0 0 {name=p118 sig_type=std_logic lab=bn1}
C {lab_pin.sym} 1260 -1460 0 0 {name=p119 sig_type=std_logic lab=bn0}
C {lab_pin.sym} 1260 -1440 0 0 {name=p120 sig_type=std_logic lab=vcm}
C {strong_arm_comp.sym} 1460 -960 0 0 {name=xcmp}
C {lab_pin.sym} 1640 -980 2 0 {name=p121 sig_type=std_logic lab=compb}
C {lab_pin.sym} 1280 -980 0 0 {name=p122 sig_type=std_logic lab=vcn}
C {lab_pin.sym} 1640 -940 2 0 {name=p123 sig_type=std_logic lab=comp}
C {lab_pin.sym} 1280 -960 0 0 {name=p124 sig_type=std_logic lab=vcp}
C {lab_pin.sym} 1460 -1050 1 0 {name=p125 sig_type=std_logic lab=vdda}
C {lab_pin.sym} 1460 -870 3 0 {name=p126 sig_type=std_logic lab=vss}
C {lab_pin.sym} 1280 -940 0 0 {name=p127 sig_type=std_logic lab=comp_clk}
C {dac_sw_2to1_tg.sym} 680 -2470 0 0 {name=xsw_bp9}
C {lab_pin.sym} 500 -2470 0 0 {name=p128 sig_type=std_logic lab=dbp9}
C {lab_pin.sym} 860 -2510 2 0 {name=p129 sig_type=std_logic lab=bp9}
C {lab_pin.sym} 680 -2370 3 0 {name=p130 sig_type=std_logic lab=vss}
C {lab_pin.sym} 680 -2570 1 0 {name=p131 sig_type=std_logic lab=vdda}
C {lab_pin.sym} 860 -2480 2 0 {name=p132 sig_type=std_logic lab=vrefp}
C {lab_pin.sym} 860 -2450 2 0 {name=p133 sig_type=std_logic lab=vcm}
C {dac_sw_2to1_tg.sym} 1240 -2470 0 0 {name=xsw_bp8}
C {lab_pin.sym} 1060 -2470 0 0 {name=p134 sig_type=std_logic lab=dbp8}
C {lab_pin.sym} 1420 -2510 2 0 {name=p135 sig_type=std_logic lab=bp8}
C {lab_pin.sym} 1240 -2370 3 0 {name=p136 sig_type=std_logic lab=vss}
C {lab_pin.sym} 1240 -2570 1 0 {name=p137 sig_type=std_logic lab=vdda}
C {lab_pin.sym} 1420 -2480 2 0 {name=p138 sig_type=std_logic lab=vrefp}
C {lab_pin.sym} 1420 -2450 2 0 {name=p139 sig_type=std_logic lab=vcm}
C {dac_sw_2to1_tg.sym} 690 -2160 0 0 {name=xsw_bp7}
C {lab_pin.sym} 510 -2160 0 0 {name=p140 sig_type=std_logic lab=dbp7}
C {lab_pin.sym} 870 -2200 2 0 {name=p141 sig_type=std_logic lab=bp7}
C {lab_pin.sym} 690 -2060 3 0 {name=p142 sig_type=std_logic lab=vss}
C {lab_pin.sym} 690 -2260 1 0 {name=p143 sig_type=std_logic lab=vdda}
C {lab_pin.sym} 870 -2170 2 0 {name=p144 sig_type=std_logic lab=vrefp}
C {lab_pin.sym} 870 -2140 2 0 {name=p145 sig_type=std_logic lab=vcm}
C {dac_sw_2to1_tg.sym} 1250 -2160 0 0 {name=xsw_bp6}
C {lab_pin.sym} 1070 -2160 0 0 {name=p146 sig_type=std_logic lab=dbp6}
C {lab_pin.sym} 1430 -2200 2 0 {name=p147 sig_type=std_logic lab=bp6}
C {lab_pin.sym} 1250 -2060 3 0 {name=p148 sig_type=std_logic lab=vss}
C {lab_pin.sym} 1250 -2260 1 0 {name=p149 sig_type=std_logic lab=vdda}
C {lab_pin.sym} 1430 -2170 2 0 {name=p150 sig_type=std_logic lab=vrefp}
C {lab_pin.sym} 1430 -2140 2 0 {name=p151 sig_type=std_logic lab=vcm}
C {dac_sw_2to1_tg.sym} 2950 -2510 0 0 {name=xsw_bp5}
C {lab_pin.sym} 2770 -2510 0 0 {name=p152 sig_type=std_logic lab=dbp5}
C {lab_pin.sym} 3130 -2550 2 0 {name=p153 sig_type=std_logic lab=bp5}
C {lab_pin.sym} 2950 -2410 3 0 {name=p154 sig_type=std_logic lab=vss}
C {lab_pin.sym} 2950 -2610 1 0 {name=p155 sig_type=std_logic lab=vdda}
C {lab_pin.sym} 3130 -2520 2 0 {name=p156 sig_type=std_logic lab=vrefp}
C {lab_pin.sym} 3130 -2490 2 0 {name=p157 sig_type=std_logic lab=vcm}
C {dac_sw_2to1_tg.sym} 3510 -2510 0 0 {name=xsw_bpr}
C {lab_pin.sym} 3330 -2510 0 0 {name=p158 sig_type=std_logic lab=dbpr}
C {lab_pin.sym} 3690 -2550 2 0 {name=p159 sig_type=std_logic lab=bpr}
C {lab_pin.sym} 3510 -2410 3 0 {name=p160 sig_type=std_logic lab=vss}
C {lab_pin.sym} 3510 -2610 1 0 {name=p161 sig_type=std_logic lab=vdda}
C {lab_pin.sym} 3690 -2520 2 0 {name=p162 sig_type=std_logic lab=vrefp}
C {lab_pin.sym} 3690 -2490 2 0 {name=p163 sig_type=std_logic lab=vcm}
C {dac_sw_2to1_tg.sym} 2950 -2130 0 0 {name=xsw_bp4}
C {lab_pin.sym} 2770 -2130 0 0 {name=p164 sig_type=std_logic lab=dbp4}
C {lab_pin.sym} 3130 -2170 2 0 {name=p165 sig_type=std_logic lab=bp4}
C {lab_pin.sym} 2950 -2030 3 0 {name=p166 sig_type=std_logic lab=vss}
C {lab_pin.sym} 2950 -2230 1 0 {name=p167 sig_type=std_logic lab=vdda}
C {lab_pin.sym} 3130 -2140 2 0 {name=p168 sig_type=std_logic lab=vrefp}
C {lab_pin.sym} 3130 -2110 2 0 {name=p169 sig_type=std_logic lab=vcm}
C {dac_sw_2to1_tg.sym} 3510 -2130 0 0 {name=xsw_bp3}
C {lab_pin.sym} 3330 -2130 0 0 {name=p170 sig_type=std_logic lab=dbp3}
C {lab_pin.sym} 3690 -2170 2 0 {name=p171 sig_type=std_logic lab=bp3}
C {lab_pin.sym} 3510 -2030 3 0 {name=p172 sig_type=std_logic lab=vss}
C {lab_pin.sym} 3510 -2230 1 0 {name=p173 sig_type=std_logic lab=vdda}
C {lab_pin.sym} 3690 -2140 2 0 {name=p174 sig_type=std_logic lab=vrefp}
C {lab_pin.sym} 3690 -2110 2 0 {name=p175 sig_type=std_logic lab=vcm}
C {dac_sw_2to1_tg.sym} 2950 -1790 0 0 {name=xsw_bp2}
C {lab_pin.sym} 2770 -1790 0 0 {name=p176 sig_type=std_logic lab=dbp2}
C {lab_pin.sym} 3130 -1830 2 0 {name=p177 sig_type=std_logic lab=bp2}
C {lab_pin.sym} 2950 -1690 3 0 {name=p178 sig_type=std_logic lab=vss}
C {lab_pin.sym} 2950 -1890 1 0 {name=p179 sig_type=std_logic lab=vdda}
C {lab_pin.sym} 3130 -1800 2 0 {name=p180 sig_type=std_logic lab=vrefp}
C {lab_pin.sym} 3130 -1770 2 0 {name=p181 sig_type=std_logic lab=vcm}
C {dac_sw_2to1_tg.sym} 3510 -1790 0 0 {name=xsw_bp1}
C {lab_pin.sym} 3330 -1790 0 0 {name=p182 sig_type=std_logic lab=dbp1}
C {lab_pin.sym} 3690 -1830 2 0 {name=p183 sig_type=std_logic lab=bp1}
C {lab_pin.sym} 3510 -1690 3 0 {name=p184 sig_type=std_logic lab=vss}
C {lab_pin.sym} 3510 -1890 1 0 {name=p185 sig_type=std_logic lab=vdda}
C {lab_pin.sym} 3690 -1800 2 0 {name=p186 sig_type=std_logic lab=vrefp}
C {lab_pin.sym} 3690 -1770 2 0 {name=p187 sig_type=std_logic lab=vcm}
C {dac_sw_2to1_tg.sym} 2970 -1450 0 0 {name=xsw_bp0}
C {lab_pin.sym} 2790 -1450 0 0 {name=p188 sig_type=std_logic lab=dbp0}
C {lab_pin.sym} 3150 -1490 2 0 {name=p189 sig_type=std_logic lab=bp0}
C {lab_pin.sym} 2970 -1350 3 0 {name=p190 sig_type=std_logic lab=vss}
C {lab_pin.sym} 2970 -1550 1 0 {name=p191 sig_type=std_logic lab=vdda}
C {lab_pin.sym} 3150 -1460 2 0 {name=p192 sig_type=std_logic lab=vrefp}
C {lab_pin.sym} 3150 -1430 2 0 {name=p193 sig_type=std_logic lab=vcm}
C {dac_sw_2to1_tg.sym} 1830 -2470 0 0 {name=xsw_bn9}
C {lab_pin.sym} 1650 -2470 0 0 {name=p194 sig_type=std_logic lab=dbn9}
C {lab_pin.sym} 2010 -2510 2 0 {name=p195 sig_type=std_logic lab=bn9}
C {lab_pin.sym} 1830 -2370 3 0 {name=p196 sig_type=std_logic lab=vss}
C {lab_pin.sym} 1830 -2570 1 0 {name=p197 sig_type=std_logic lab=vdda}
C {lab_pin.sym} 2010 -2480 2 0 {name=p198 sig_type=std_logic lab=vrefp}
C {lab_pin.sym} 2010 -2450 2 0 {name=p199 sig_type=std_logic lab=vcm}
C {dac_sw_2to1_tg.sym} 2390 -2470 0 0 {name=xsw_bn8}
C {lab_pin.sym} 2210 -2470 0 0 {name=p200 sig_type=std_logic lab=dbn8}
C {lab_pin.sym} 2570 -2510 2 0 {name=p201 sig_type=std_logic lab=bn8}
C {lab_pin.sym} 2390 -2370 3 0 {name=p202 sig_type=std_logic lab=vss}
C {lab_pin.sym} 2390 -2570 1 0 {name=p203 sig_type=std_logic lab=vdda}
C {lab_pin.sym} 2570 -2480 2 0 {name=p204 sig_type=std_logic lab=vrefp}
C {lab_pin.sym} 2570 -2450 2 0 {name=p205 sig_type=std_logic lab=vcm}
C {dac_sw_2to1_tg.sym} 1840 -2160 0 0 {name=xsw_bn7}
C {lab_pin.sym} 1660 -2160 0 0 {name=p206 sig_type=std_logic lab=dbn7}
C {lab_pin.sym} 2020 -2200 2 0 {name=p207 sig_type=std_logic lab=bn7}
C {lab_pin.sym} 1840 -2060 3 0 {name=p208 sig_type=std_logic lab=vss}
C {lab_pin.sym} 1840 -2260 1 0 {name=p209 sig_type=std_logic lab=vdda}
C {lab_pin.sym} 2020 -2170 2 0 {name=p210 sig_type=std_logic lab=vrefp}
C {lab_pin.sym} 2020 -2140 2 0 {name=p211 sig_type=std_logic lab=vcm}
C {dac_sw_2to1_tg.sym} 2400 -2160 0 0 {name=xsw_bn6}
C {lab_pin.sym} 2220 -2160 0 0 {name=p212 sig_type=std_logic lab=dbn6}
C {lab_pin.sym} 2580 -2200 2 0 {name=p213 sig_type=std_logic lab=bn6}
C {lab_pin.sym} 2400 -2060 3 0 {name=p214 sig_type=std_logic lab=vss}
C {lab_pin.sym} 2400 -2260 1 0 {name=p215 sig_type=std_logic lab=vdda}
C {lab_pin.sym} 2580 -2170 2 0 {name=p216 sig_type=std_logic lab=vrefp}
C {lab_pin.sym} 2580 -2140 2 0 {name=p217 sig_type=std_logic lab=vcm}
C {dac_sw_2to1_tg.sym} 4100 -2510 0 0 {name=xsw_bn5}
C {lab_pin.sym} 3920 -2510 0 0 {name=p218 sig_type=std_logic lab=dbn5}
C {lab_pin.sym} 4280 -2550 2 0 {name=p219 sig_type=std_logic lab=bn5}
C {lab_pin.sym} 4100 -2410 3 0 {name=p220 sig_type=std_logic lab=vss}
C {lab_pin.sym} 4100 -2610 1 0 {name=p221 sig_type=std_logic lab=vdda}
C {lab_pin.sym} 4280 -2520 2 0 {name=p222 sig_type=std_logic lab=vrefp}
C {lab_pin.sym} 4280 -2490 2 0 {name=p223 sig_type=std_logic lab=vcm}
C {dac_sw_2to1_tg.sym} 4660 -2510 0 0 {name=xsw_bnr}
C {lab_pin.sym} 4480 -2510 0 0 {name=p224 sig_type=std_logic lab=dbnr}
C {lab_pin.sym} 4840 -2550 2 0 {name=p225 sig_type=std_logic lab=bnr}
C {lab_pin.sym} 4660 -2410 3 0 {name=p226 sig_type=std_logic lab=vss}
C {lab_pin.sym} 4660 -2610 1 0 {name=p227 sig_type=std_logic lab=vdda}
C {lab_pin.sym} 4840 -2520 2 0 {name=p228 sig_type=std_logic lab=vrefp}
C {lab_pin.sym} 4840 -2490 2 0 {name=p229 sig_type=std_logic lab=vcm}
C {dac_sw_2to1_tg.sym} 4100 -2130 0 0 {name=xsw_bn4}
C {lab_pin.sym} 3920 -2130 0 0 {name=p230 sig_type=std_logic lab=dbn4}
C {lab_pin.sym} 4280 -2170 2 0 {name=p231 sig_type=std_logic lab=bn4}
C {lab_pin.sym} 4100 -2030 3 0 {name=p232 sig_type=std_logic lab=vss}
C {lab_pin.sym} 4100 -2230 1 0 {name=p233 sig_type=std_logic lab=vdda}
C {lab_pin.sym} 4280 -2140 2 0 {name=p234 sig_type=std_logic lab=vrefp}
C {lab_pin.sym} 4280 -2110 2 0 {name=p235 sig_type=std_logic lab=vcm}
C {dac_sw_2to1_tg.sym} 4660 -2130 0 0 {name=xsw_bn3}
C {lab_pin.sym} 4480 -2130 0 0 {name=p236 sig_type=std_logic lab=dbn3}
C {lab_pin.sym} 4840 -2170 2 0 {name=p237 sig_type=std_logic lab=bn3}
C {lab_pin.sym} 4660 -2030 3 0 {name=p238 sig_type=std_logic lab=vss}
C {lab_pin.sym} 4660 -2230 1 0 {name=p239 sig_type=std_logic lab=vdda}
C {lab_pin.sym} 4840 -2140 2 0 {name=p240 sig_type=std_logic lab=vrefp}
C {lab_pin.sym} 4840 -2110 2 0 {name=p241 sig_type=std_logic lab=vcm}
C {dac_sw_2to1_tg.sym} 4100 -1790 0 0 {name=xsw_bn2}
C {lab_pin.sym} 3920 -1790 0 0 {name=p242 sig_type=std_logic lab=dbn2}
C {lab_pin.sym} 4280 -1830 2 0 {name=p243 sig_type=std_logic lab=bn2}
C {lab_pin.sym} 4100 -1690 3 0 {name=p244 sig_type=std_logic lab=vss}
C {lab_pin.sym} 4100 -1890 1 0 {name=p245 sig_type=std_logic lab=vdda}
C {lab_pin.sym} 4280 -1800 2 0 {name=p246 sig_type=std_logic lab=vrefp}
C {lab_pin.sym} 4280 -1770 2 0 {name=p247 sig_type=std_logic lab=vcm}
C {dac_sw_2to1_tg.sym} 4660 -1790 0 0 {name=xsw_bn1}
C {lab_pin.sym} 4480 -1790 0 0 {name=p248 sig_type=std_logic lab=dbn1}
C {lab_pin.sym} 4840 -1830 2 0 {name=p249 sig_type=std_logic lab=bn1}
C {lab_pin.sym} 4660 -1690 3 0 {name=p250 sig_type=std_logic lab=vss}
C {lab_pin.sym} 4660 -1890 1 0 {name=p251 sig_type=std_logic lab=vdda}
C {lab_pin.sym} 4840 -1800 2 0 {name=p252 sig_type=std_logic lab=vrefp}
C {lab_pin.sym} 4840 -1770 2 0 {name=p253 sig_type=std_logic lab=vcm}
C {dac_sw_2to1_tg.sym} 4120 -1450 0 0 {name=xsw_bn0}
C {lab_pin.sym} 3940 -1450 0 0 {name=p254 sig_type=std_logic lab=dbn0}
C {lab_pin.sym} 4300 -1490 2 0 {name=p255 sig_type=std_logic lab=bn0}
C {lab_pin.sym} 4120 -1350 3 0 {name=p256 sig_type=std_logic lab=vss}
C {lab_pin.sym} 4120 -1550 1 0 {name=p257 sig_type=std_logic lab=vdda}
C {lab_pin.sym} 4300 -1460 2 0 {name=p258 sig_type=std_logic lab=vrefp}
C {lab_pin.sym} 4300 -1430 2 0 {name=p259 sig_type=std_logic lab=vcm}
C {sar_split_cal_ctrl.sym} 2310 -770 0 0 {name=xctrl model=sar_split_cal_ctrl}
C {lab_pin.sym} 2070 -1270 0 0 {name=p260 sig_type=std_logic lab=vddd}
C {lab_pin.sym} 2070 -1250 0 0 {name=p261 sig_type=std_logic lab=vss}
C {lab_pin.sym} 2070 -1210 0 0 {name=p262 sig_type=std_logic lab=clk}
C {lab_pin.sym} 2070 -1190 0 0 {name=p263 sig_type=std_logic lab=rst_n}
C {lab_pin.sym} 2070 -1170 0 0 {name=p264 sig_type=std_logic lab=start}
C {lab_pin.sym} 2070 -1150 0 0 {name=p265 sig_type=std_logic lab=comp}
C {lab_pin.sym} 2070 -1130 0 0 {name=p266 sig_type=std_logic lab=cal_en}
C {lab_pin.sym} 2070 -1110 0 0 {name=p267 sig_type=std_logic lab=cal_we}
C {lab_pin.sym} 2070 -1090 0 0 {name=p268 sig_type=std_logic lab=cal_addr3}
C {lab_pin.sym} 2070 -1070 0 0 {name=p269 sig_type=std_logic lab=cal_addr2}
C {lab_pin.sym} 2070 -1050 0 0 {name=p270 sig_type=std_logic lab=cal_addr1}
C {lab_pin.sym} 2070 -1030 0 0 {name=p271 sig_type=std_logic lab=cal_addr0}
C {lab_pin.sym} 2070 -1010 0 0 {name=p272 sig_type=std_logic lab=cal_wdata17}
C {lab_pin.sym} 2070 -990 0 0 {name=p273 sig_type=std_logic lab=cal_wdata16}
C {lab_pin.sym} 2070 -970 0 0 {name=p274 sig_type=std_logic lab=cal_wdata15}
C {lab_pin.sym} 2070 -950 0 0 {name=p275 sig_type=std_logic lab=cal_wdata14}
C {lab_pin.sym} 2070 -930 0 0 {name=p276 sig_type=std_logic lab=cal_wdata13}
C {lab_pin.sym} 2070 -910 0 0 {name=p277 sig_type=std_logic lab=cal_wdata12}
C {lab_pin.sym} 2070 -890 0 0 {name=p278 sig_type=std_logic lab=cal_wdata11}
C {lab_pin.sym} 2070 -870 0 0 {name=p279 sig_type=std_logic lab=cal_wdata10}
C {lab_pin.sym} 2070 -850 0 0 {name=p280 sig_type=std_logic lab=cal_wdata9}
C {lab_pin.sym} 2070 -830 0 0 {name=p281 sig_type=std_logic lab=cal_wdata8}
C {lab_pin.sym} 2070 -810 0 0 {name=p282 sig_type=std_logic lab=cal_wdata7}
C {lab_pin.sym} 2070 -790 0 0 {name=p283 sig_type=std_logic lab=cal_wdata6}
C {lab_pin.sym} 2070 -770 0 0 {name=p284 sig_type=std_logic lab=cal_wdata5}
C {lab_pin.sym} 2070 -750 0 0 {name=p285 sig_type=std_logic lab=cal_wdata4}
C {lab_pin.sym} 2070 -730 0 0 {name=p286 sig_type=std_logic lab=cal_wdata3}
C {lab_pin.sym} 2070 -710 0 0 {name=p287 sig_type=std_logic lab=cal_wdata2}
C {lab_pin.sym} 2070 -690 0 0 {name=p288 sig_type=std_logic lab=cal_wdata1}
C {lab_pin.sym} 2070 -670 0 0 {name=p289 sig_type=std_logic lab=cal_wdata0}
C {lab_pin.sym} 2550 -1270 2 0 {name=p290 sig_type=std_logic lab=sample}
C {lab_pin.sym} 2550 -1250 2 0 {name=p291 sig_type=std_logic lab=rstf}
C {lab_pin.sym} 2550 -1230 2 0 {name=p292 sig_type=std_logic lab=comp_clk}
C {lab_pin.sym} 2550 -1210 2 0 {name=p293 sig_type=std_logic lab=busy}
C {lab_pin.sym} 2550 -1190 2 0 {name=p294 sig_type=std_logic lab=valid}
C {lab_pin.sym} 2550 -1170 2 0 {name=p295 sig_type=std_logic lab=raw_stb}
C {lab_pin.sym} 2550 -1150 2 0 {name=p296 sig_type=std_logic lab=sat}
C {lab_pin.sym} 2550 -1130 2 0 {name=p297 sig_type=std_logic lab=dbp9}
C {lab_pin.sym} 2550 -1110 2 0 {name=p298 sig_type=std_logic lab=dbp8}
C {lab_pin.sym} 2550 -1090 2 0 {name=p299 sig_type=std_logic lab=dbp7}
C {lab_pin.sym} 2550 -1070 2 0 {name=p300 sig_type=std_logic lab=dbp6}
C {lab_pin.sym} 2550 -1050 2 0 {name=p301 sig_type=std_logic lab=dbp5}
C {lab_pin.sym} 2550 -1030 2 0 {name=p302 sig_type=std_logic lab=dbpr}
C {lab_pin.sym} 2550 -1010 2 0 {name=p303 sig_type=std_logic lab=dbp4}
C {lab_pin.sym} 2550 -990 2 0 {name=p304 sig_type=std_logic lab=dbp3}
C {lab_pin.sym} 2550 -970 2 0 {name=p305 sig_type=std_logic lab=dbp2}
C {lab_pin.sym} 2550 -950 2 0 {name=p306 sig_type=std_logic lab=dbp1}
C {lab_pin.sym} 2550 -930 2 0 {name=p307 sig_type=std_logic lab=dbp0}
C {lab_pin.sym} 2550 -910 2 0 {name=p308 sig_type=std_logic lab=dbn9}
C {lab_pin.sym} 2550 -890 2 0 {name=p309 sig_type=std_logic lab=dbn8}
C {lab_pin.sym} 2550 -870 2 0 {name=p310 sig_type=std_logic lab=dbn7}
C {lab_pin.sym} 2550 -850 2 0 {name=p311 sig_type=std_logic lab=dbn6}
C {lab_pin.sym} 2550 -830 2 0 {name=p312 sig_type=std_logic lab=dbn5}
C {lab_pin.sym} 2550 -810 2 0 {name=p313 sig_type=std_logic lab=dbnr}
C {lab_pin.sym} 2550 -790 2 0 {name=p314 sig_type=std_logic lab=dbn4}
C {lab_pin.sym} 2550 -770 2 0 {name=p315 sig_type=std_logic lab=dbn3}
C {lab_pin.sym} 2550 -750 2 0 {name=p316 sig_type=std_logic lab=dbn2}
C {lab_pin.sym} 2550 -730 2 0 {name=p317 sig_type=std_logic lab=dbn1}
C {lab_pin.sym} 2550 -710 2 0 {name=p318 sig_type=std_logic lab=dbn0}
C {lab_pin.sym} 2550 -690 2 0 {name=p319 sig_type=std_logic lab=code9}
C {lab_pin.sym} 2550 -670 2 0 {name=p320 sig_type=std_logic lab=code8}
C {lab_pin.sym} 2550 -650 2 0 {name=p321 sig_type=std_logic lab=code7}
C {lab_pin.sym} 2550 -630 2 0 {name=p322 sig_type=std_logic lab=code6}
C {lab_pin.sym} 2550 -610 2 0 {name=p323 sig_type=std_logic lab=code5}
C {lab_pin.sym} 2550 -590 2 0 {name=p324 sig_type=std_logic lab=code4}
C {lab_pin.sym} 2550 -570 2 0 {name=p325 sig_type=std_logic lab=code3}
C {lab_pin.sym} 2550 -550 2 0 {name=p326 sig_type=std_logic lab=code2}
C {lab_pin.sym} 2550 -530 2 0 {name=p327 sig_type=std_logic lab=code1}
C {lab_pin.sym} 2550 -510 2 0 {name=p328 sig_type=std_logic lab=code0}
C {lab_pin.sym} 2550 -490 2 0 {name=p329 sig_type=std_logic lab=raw11}
C {lab_pin.sym} 2550 -470 2 0 {name=p330 sig_type=std_logic lab=raw10}
C {lab_pin.sym} 2550 -450 2 0 {name=p331 sig_type=std_logic lab=raw9}
C {lab_pin.sym} 2550 -430 2 0 {name=p332 sig_type=std_logic lab=raw8}
C {lab_pin.sym} 2550 -410 2 0 {name=p333 sig_type=std_logic lab=raw7}
C {lab_pin.sym} 2550 -390 2 0 {name=p334 sig_type=std_logic lab=raw6}
C {lab_pin.sym} 2550 -370 2 0 {name=p335 sig_type=std_logic lab=raw5}
C {lab_pin.sym} 2550 -350 2 0 {name=p336 sig_type=std_logic lab=raw4}
C {lab_pin.sym} 2550 -330 2 0 {name=p337 sig_type=std_logic lab=raw3}
C {lab_pin.sym} 2550 -310 2 0 {name=p338 sig_type=std_logic lab=raw2}
C {lab_pin.sym} 2550 -290 2 0 {name=p339 sig_type=std_logic lab=raw1}
C {lab_pin.sym} 2550 -270 2 0 {name=p340 sig_type=std_logic lab=raw0}
C {title.sym} 160 0 0 0 {name=l1 author="Arjun Ananth"}
