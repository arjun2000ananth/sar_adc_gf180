** sch_path: circuit_files/tb/sar_10_bit_split_cal_tb.sch
**.subckt sar_10_bit_split_cal_tb
x1 vdda vddd vss ainp ainn vcm vrefp clk rst_n start GND GND GND GND GND GND GND GND GND GND GND GND
+ GND GND GND GND GND GND GND GND GND GND GND GND busy valid sat raw_stb code9 code8 code7 code6 code5
+ code4 code3 code2 code1 code0 raw11 raw10 raw9 raw8 raw7 raw6 raw5 raw4 raw3 raw2 raw1 raw0
+ sar_10_bit_split_cal
VDDA vdda GND dc 3.3
VDDD vddd GND dc 3.3
VSSS vss GND dc 0
VREF vrefp GND dc 3.3
VCMS vcm GND dc 1.65
VINP ainp_s GND dc {1.65+VDIFF/2}
VINN ainn_s GND dc {1.65-VDIFF/2}
VCKI cki GND PULSE(0 3.3 10n 0.2n 0.2n 9.8n 20n)
VRST rst_n GND PWL(0 0 100n 0 100.2n 3.3)
VSTA start GND PWL(0 0 160n 0 160.2n 3.3)
RSP ainp_s ainp 50 m=1
RSN ainn_s ainn 50 m=1
**** begin user architecture code

.include $::env(PDK_ROOT)/$::env(PDK)/libs.tech/ngspice/design.ngspice
.lib $::env(PDK_ROOT)/$::env(PDK)/libs.tech/ngspice/sm141064.ngspice typical
.lib $::env(PDK_ROOT)/$::env(PDK)/libs.tech/ngspice/sm141064.ngspice cap_mim
.lib $::env(PDK_ROOT)/$::env(PDK)/libs.tech/ngspice/sm141064.ngspice mimcap_typical
.include $::env(PDK_ROOT)/$::env(PDK)/libs.ref/gf180mcu_fd_sc_mcu7t5v0/spice/gf180mcu_fd_sc_mcu7t5v0.spice
.include [file dirname [xschem get schname]]/../src/sar_split_cal/xspice/sar_split_cal_ctrl_as_xspice.spice



.param VDIFF=0.5
XCKB cki clk vddd vddd vss vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_4
.options method=gear reltol=1e-4 abstol=1e-12 vntol=1e-6 klu
.control
set noaskquit
save v(clk) v(valid) v(sat) v(x1.sample) v(x1.rstf) v(x1.comp_clk) v(x1.comp) v(x1.vcp) v(x1.vcn)
+ v(x1.vfp) v(x1.vfn) v(code0) v(code1) v(code2) v(code3) v(code4) v(code5) v(code6) v(code7) v(code8) v(code9)
+ v(raw0) v(raw1) v(raw2) v(raw3) v(raw4) v(raw5) v(raw6) v(raw7) v(raw8) v(raw9) v(raw10) v(raw11)
tran 1n 6.5u
write sar_10_bit_split_cal_tb.raw
set wr_singlescale
linearize v(valid) v(sat) v(code0) v(code1) v(code2) v(code3) v(code4) v(code5) v(code6) v(code7)
+ v(code8) v(code9) v(raw0) v(raw1) v(raw2) v(raw3) v(raw4) v(raw5) v(raw6) v(raw7) v(raw8) v(raw9) v(raw10)
+ v(raw11)
wrdata dlog.txt v(valid) v(sat) v(code0) v(code1) v(code2) v(code3) v(code4) v(code5) v(code6)
+ v(code7) v(code8) v(code9) v(raw0) v(raw1) v(raw2) v(raw3) v(raw4) v(raw5) v(raw6) v(raw7) v(raw8) v(raw9)
+ v(raw10) v(raw11)
echo done
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
