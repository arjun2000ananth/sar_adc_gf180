** sch_path: circuit_files/tb/sar_10_bit_tb.sch
**.subckt sar_10_bit_tb C1 C2 C3 C4 C5 C6 C7 C8 C0 C9 busy valid Voutn
*.opin C1
*.opin C2
*.opin C3
*.opin C4
*.opin C5
*.opin C6
*.opin C7
*.opin C8
*.opin C0
*.opin C9
*.opin busy
*.opin valid
*.iopin Voutn
x1 RSTN busy START valid vcm vrefp ainn ainp CLK C0 C9 C1 C5 C6 C2 C7 C3 C8 C4 vss vdd Voutn
+ sar_10_bit
V_VIN ainn GND dc {VCM - VDIFF/2}
VDD_SRC vdd GND dc {VDD}
V_VINP ainp GND dc {VCM + VDIFF/2}
V_VSS vss GND dc 0
V_CLK CLK GND PULSE(0 3.3 0n 20p 20p 10n 20n)
V_VCM1 vcm GND dc {VCM}
VREFP_SRC vrefp GND dc {VDD}
V_RSTN RSTN GND PULSE(0 3.3 60n 20p 20p 10u 20u)
V_START START GND PULSE(0 3.3 100n 20p 20p 20n 2u)
**** begin user architecture code

.include $::env(PDK_ROOT)/$::env(PDK)/libs.tech/ngspice/design.ngspice

.lib $::env(PDK_ROOT)/$::env(PDK)/libs.tech/ngspice/sm141064.ngspice typical
.lib $::env(PDK_ROOT)/$::env(PDK)/libs.tech/ngspice/sm141064.ngspice res_typical
.lib $::env(PDK_ROOT)/$::env(PDK)/libs.tech/ngspice/sm141064.ngspice moscap_typical
.lib $::env(PDK_ROOT)/$::env(PDK)/libs.tech/ngspice/sm141064.ngspice diode_typical
.lib $::env(PDK_ROOT)/$::env(PDK)/libs.tech/ngspice/sm141064.ngspice cap_mim
.lib $::env(PDK_ROOT)/$::env(PDK)/libs.tech/ngspice/sm141064.ngspice mimcap_typical

.include $::env(PDK_ROOT)/$::env(PDK)/libs.ref/gf180mcu_fd_io/spice/gf180mcu_fd_io.spice
* moved from block s1 (needs tcleval): standard cells and controller wrapper
.include $::env(PDK_ROOT)/$::env(PDK)/libs.ref/gf180mcu_fd_sc_mcu7t5v0/spice/gf180mcu_fd_sc_mcu7t5v0.spice
.include [file dirname [xschem get schname]]/../src/sar_fsm/sar_fsm_wrapper_fixed.spice



* ============================================================
* GF180 / SAR FSM + Comparator + CDAC mixed-signal testbench
* REAL DAC-switch version
* ============================================================

* Standard-cell SPICE and SAR FSM wrapper

* ------------------------------------------------------------
* Main parameters
* ------------------------------------------------------------
.param VDD=3.3
.param VCM=1.65
.param VDIFF=0.001611328125



* ============================================================
* SAR ADC FULL-RANGE RAMP DEBUG THROUGH sar_10_bit SYMBOL
* Top ADC instance name: x1
*
* Top-level visible:
*   CLK RSTN START ainp ainn busy valid C9..C0 Voutn
*
* Internal to sar_10_bit:
*   x1.vcp, x1.vcn, x1.voutp
*   x1.sample, x1.sampleb, x1.comp_clk
*   x1.dbp9..x1.dbp0, x1.dbn9..x1.dbn0
*   x1.bp9..x1.bp0,   x1.bn9..x1.bn0
* ============================================================

.options reltol=1e-4 abstol=1e-12 vntol=1e-6
.options method=gear maxord=2
.options plotwinsize=0

* -----------------------------
* Save top-level nodes
* -----------------------------
.save v(CLK) v(RSTN) v(START)
.save v(ainp) v(ainn)
.save v(vrefp) v(vcm)
.save v(busy) v(valid)
.save v(Voutn)

.save v(C9) v(C8) v(C7) v(C6) v(C5)
.save v(C4) v(C3) v(C2) v(C1) v(C0)

* -----------------------------
* Save internal ADC debug nodes
* -----------------------------
.save v(x1.sample) v(x1.sampleb) v(x1.comp_clk)
.save v(x1.vcp) v(x1.vcn)
.save v(x1.voutp)

.save v(x1.dbp9) v(x1.dbp8) v(x1.dbp7) v(x1.dbp6) v(x1.dbp5)
.save v(x1.dbp4) v(x1.dbp3) v(x1.dbp2) v(x1.dbp1) v(x1.dbp0)

.save v(x1.dbn9) v(x1.dbn8) v(x1.dbn7) v(x1.dbn6) v(x1.dbn5)
.save v(x1.dbn4) v(x1.dbn3) v(x1.dbn2) v(x1.dbn1) v(x1.dbn0)

.save v(x1.bp9) v(x1.bp8) v(x1.bp7) v(x1.bp6) v(x1.bp5)
.save v(x1.bp4) v(x1.bp3) v(x1.bp2) v(x1.bp1) v(x1.bp0)

.save v(x1.bn9) v(x1.bn8) v(x1.bn7) v(x1.bn6) v(x1.bn5)
.save v(x1.bn4) v(x1.bn3) v(x1.bn2) v(x1.bn1) v(x1.bn0)


.control

set noaskquit

shell rm -f sar_fullrange_symbol_results.txt

let logic_th = 1.65
let prev_code = -1
let run_index = 0
let monotonic_fail_count = 0
let missing_jump_count = 0

echo VDIFF VIN_MEAS VALID_SEEN T_DEBUG CODE C9 C8 C7 C6 C5 C4 C3 C2 C1 C0 AINP AINN VCP VCN
+ VCP_MINUS_VCN VOUTP VOUTN DBP9 DBP8 DBP7 DBP6 DBP5 DBP4 DBP3 DBP2 DBP1 DBP0 DBN9 DBN8 DBN7 DBN6 DBN5 DBN4 DBN3
+ DBN2 DBN1 DBN0 BP9 BP8 BP7 BP6 BP5 BP4 BP3 BP2 BP1 BP0 BN9 BN8 BN7 BN6 BN5 BN4 BN3 BN2 BN1 BN0
+ MONOTONIC_FAIL MISSING_JUMP > sar_fullrange_symbol_results.txt

* Full-range sanity sweep.
* LSB = 3.3/1024 = 3.22265625m
* 0.001611328125 = 0.5 LSB
* 0.00322265625  = 1 LSB
* 0.0064453125   = 2 LSB
foreach vdiff_val -1.6 -1.2 -0.8 -0.4 -0.1 -0.020 -0.010 -0.0064453125 -0.00322265625
+ -0.001611328125 0 0.001611328125 0.00322265625 0.0064453125 0.010 0.020 0.1 0.4 0.8 1.2 1.6

  alterparam VDIFF = $vdiff_val
  reset

  tran 20p 1.6u

  meas tran valid_max MAX v(valid) FROM=0n TO=1.6u

  let valid_seen = 0
  if valid_max > logic_th
    let valid_seen = 1
  end

  let t_debug = 1.55u
  if valid_seen > 0.5
    meas tran t_valid WHEN v(valid)=1.65 RISE=1
    let t_debug = t_valid + 5n
  end

  * -----------------------------
  * Top-level input check
  * -----------------------------
  meas tran ainpv FIND v(ainp) AT=$&t_debug
  meas tran ainnv FIND v(ainn) AT=$&t_debug
  let vin_meas = ainpv - ainnv

  * -----------------------------
  * Top-level code bits
  * -----------------------------
  meas tran c9v FIND v(C9) AT=$&t_debug
  meas tran c8v FIND v(C8) AT=$&t_debug
  meas tran c7v FIND v(C7) AT=$&t_debug
  meas tran c6v FIND v(C6) AT=$&t_debug
  meas tran c5v FIND v(C5) AT=$&t_debug
  meas tran c4v FIND v(C4) AT=$&t_debug
  meas tran c3v FIND v(C3) AT=$&t_debug
  meas tran c2v FIND v(C2) AT=$&t_debug
  meas tran c1v FIND v(C1) AT=$&t_debug
  meas tran c0v FIND v(C0) AT=$&t_debug

  let b9 = 0
  if c9v > logic_th
    let b9 = 1
  end

  let b8 = 0
  if c8v > logic_th
    let b8 = 1
  end

  let b7 = 0
  if c7v > logic_th
    let b7 = 1
  end

  let b6 = 0
  if c6v > logic_th
    let b6 = 1
  end

  let b5 = 0
  if c5v > logic_th
    let b5 = 1
  end

  let b4 = 0
  if c4v > logic_th
    let b4 = 1
  end

  let b3 = 0
  if c3v > logic_th
    let b3 = 1
  end

  let b2 = 0
  if c2v > logic_th
    let b2 = 1
  end

  let b1 = 0
  if c1v > logic_th
    let b1 = 1
  end

  let b0 = 0
  if c0v > logic_th
    let b0 = 1
  end

  let adc_code = 512*b9 + 256*b8 + 128*b7 + 64*b6 + 32*b5 + 16*b4 + 8*b3 + 4*b2 + 2*b1 + b0

  * -----------------------------
  * Internal ADC analog values
  * -----------------------------
  meas tran vcpv    FIND v(x1.vcp)    AT=$&t_debug
  meas tran vcnv    FIND v(x1.vcn)    AT=$&t_debug
  meas tran voutpv  FIND v(x1.voutp)  AT=$&t_debug
  meas tran voutnv  FIND v(Voutn)     AT=$&t_debug

  let vdiff_cdac = vcpv - vcnv

  * -----------------------------
  * Internal SAR DAC digital controls
  * -----------------------------
  meas tran dbp9v FIND v(x1.dbp9) AT=$&t_debug
  meas tran dbp8v FIND v(x1.dbp8) AT=$&t_debug
  meas tran dbp7v FIND v(x1.dbp7) AT=$&t_debug
  meas tran dbp6v FIND v(x1.dbp6) AT=$&t_debug
  meas tran dbp5v FIND v(x1.dbp5) AT=$&t_debug
  meas tran dbp4v FIND v(x1.dbp4) AT=$&t_debug
  meas tran dbp3v FIND v(x1.dbp3) AT=$&t_debug
  meas tran dbp2v FIND v(x1.dbp2) AT=$&t_debug
  meas tran dbp1v FIND v(x1.dbp1) AT=$&t_debug
  meas tran dbp0v FIND v(x1.dbp0) AT=$&t_debug

  meas tran dbn9v FIND v(x1.dbn9) AT=$&t_debug
  meas tran dbn8v FIND v(x1.dbn8) AT=$&t_debug
  meas tran dbn7v FIND v(x1.dbn7) AT=$&t_debug
  meas tran dbn6v FIND v(x1.dbn6) AT=$&t_debug
  meas tran dbn5v FIND v(x1.dbn5) AT=$&t_debug
  meas tran dbn4v FIND v(x1.dbn4) AT=$&t_debug
  meas tran dbn3v FIND v(x1.dbn3) AT=$&t_debug
  meas tran dbn2v FIND v(x1.dbn2) AT=$&t_debug
  meas tran dbn1v FIND v(x1.dbn1) AT=$&t_debug
  meas tran dbn0v FIND v(x1.dbn0) AT=$&t_debug

  * -----------------------------
  * Internal actual CDAC bottom plates
  * -----------------------------
  meas tran bp9v FIND v(x1.bp9) AT=$&t_debug
  meas tran bp8v FIND v(x1.bp8) AT=$&t_debug
  meas tran bp7v FIND v(x1.bp7) AT=$&t_debug
  meas tran bp6v FIND v(x1.bp6) AT=$&t_debug
  meas tran bp5v FIND v(x1.bp5) AT=$&t_debug
  meas tran bp4v FIND v(x1.bp4) AT=$&t_debug
  meas tran bp3v FIND v(x1.bp3) AT=$&t_debug
  meas tran bp2v FIND v(x1.bp2) AT=$&t_debug
  meas tran bp1v FIND v(x1.bp1) AT=$&t_debug
  meas tran bp0v FIND v(x1.bp0) AT=$&t_debug

  meas tran bn9v FIND v(x1.bn9) AT=$&t_debug
  meas tran bn8v FIND v(x1.bn8) AT=$&t_debug
  meas tran bn7v FIND v(x1.bn7) AT=$&t_debug
  meas tran bn6v FIND v(x1.bn6) AT=$&t_debug
  meas tran bn5v FIND v(x1.bn5) AT=$&t_debug
  meas tran bn4v FIND v(x1.bn4) AT=$&t_debug
  meas tran bn3v FIND v(x1.bn3) AT=$&t_debug
  meas tran bn2v FIND v(x1.bn2) AT=$&t_debug
  meas tran bn1v FIND v(x1.bn1) AT=$&t_debug
  meas tran bn0v FIND v(x1.bn0) AT=$&t_debug

  * -----------------------------
  * Checks
  * -----------------------------
  let monotonic_fail = 0
  let missing_jump = 0

  if run_index > 0
    if adc_code < prev_code
      let monotonic_fail = 1
      let monotonic_fail_count = monotonic_fail_count + 1
    end

    * This is only a coarse warning for this sparse sweep.
    * Large jumps are expected for large input steps, so only flag near-midscale small steps.
    if vdiff_val > -0.025
      if vdiff_val < 0.025
        if adc_code > prev_code + 4
          let missing_jump = 1
          let missing_jump_count = missing_jump_count + 1
        end
      end
    end
  end

  echo $vdiff_val $&vin_meas $&valid_seen $&t_debug $&adc_code $&b9 $&b8 $&b7 $&b6 $&b5 $&b4 $&b3
+ $&b2 $&b1 $&b0 $&ainpv $&ainnv $&vcpv $&vcnv $&vdiff_cdac $&voutpv $&voutnv $&dbp9v $&dbp8v $&dbp7v
+ $&dbp6v $&dbp5v $&dbp4v $&dbp3v $&dbp2v $&dbp1v $&dbp0v $&dbn9v $&dbn8v $&dbn7v $&dbn6v $&dbn5v $&dbn4v
+ $&dbn3v $&dbn2v $&dbn1v $&dbn0v $&bp9v $&bp8v $&bp7v $&bp6v $&bp5v $&bp4v $&bp3v $&bp2v $&bp1v $&bp0v
+ $&bn9v $&bn8v $&bn7v $&bn6v $&bn5v $&bn4v $&bn3v $&bn2v $&bn1v $&bn0v $&monotonic_fail $&missing_jump >>
+ sar_fullrange_symbol_results.txt

  let prev_code = adc_code
  let run_index = run_index + 1

end

echo ================================================== >> sar_fullrange_symbol_results.txt
echo RAMP_SUMMARY >> sar_fullrange_symbol_results.txt
echo number_of_points = $&run_index >> sar_fullrange_symbol_results.txt
echo monotonic_fail_count = $&monotonic_fail_count >> sar_fullrange_symbol_results.txt
echo missing_jump_count_sparse_near_midscale = $&missing_jump_count >>
+ sar_fullrange_symbol_results.txt
echo Expected: code should move monotonically upward with VDIFF. >> sar_fullrange_symbol_results.txt
echo Expected: near VDIFF=0, code should be close to 511 or 512. >> sar_fullrange_symbol_results.txt
echo Expected: near VDIFF=-1.6, code should be close to low end. >> sar_fullrange_symbol_results.txt
echo Expected: near VDIFF=+1.6, code should be close to high end. >>
+ sar_fullrange_symbol_results.txt
echo ================================================== >> sar_fullrange_symbol_results.txt

echo ==================================================
echo SAR full-range symbol-level ramp test complete.
echo Results written to sar_fullrange_symbol_results.txt
echo ==================================================

.endc



**** end user architecture code
**.ends
.GLOBAL GND
.end
