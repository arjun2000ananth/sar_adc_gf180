** sch_path: circuit_files/tb/cdac_caps_10b_diff_split_cal_tb.sch
**.subckt cdac_caps_10b_diff_split_cal_tb
x1 vcp vfp bp9 bp8 bp7 bp6 bp5 bpr bp4 bp3 bp2 bp1 bp0 bpd vcn vfn bn9 bn8 bn7 bn6 bn5 bnr bn4 bn3
+ bn2 bn1 bn0 bnd cdac_caps_10b_diff_split_cal
V_BP9 bp9 GND PULSE(1.65 3.3 1 100p 100p 1 2)
V_BN9 bn9 GND PULSE(1.65 3.3 1 100p 100p 1 2)
V_BP8 bp8 GND PULSE(1.65 3.3 1 100p 100p 1 2)
V_BN8 bn8 GND PULSE(1.65 3.3 1 100p 100p 1 2)
V_BP7 bp7 GND PULSE(1.65 3.3 1 100p 100p 1 2)
V_BN7 bn7 GND PULSE(1.65 3.3 1 100p 100p 1 2)
V_BP6 bp6 GND PULSE(1.65 3.3 1 100p 100p 1 2)
V_BN6 bn6 GND PULSE(1.65 3.3 1 100p 100p 1 2)
V_BP5 bp5 GND PULSE(1.65 3.3 1 100p 100p 1 2)
V_BN5 bn5 GND PULSE(1.65 3.3 1 100p 100p 1 2)
V_BPR bpr GND PULSE(1.65 3.3 1 100p 100p 1 2)
V_BNR bnr GND PULSE(1.65 3.3 1 100p 100p 1 2)
V_BP4 bp4 GND PULSE(1.65 3.3 1 100p 100p 1 2)
V_BN4 bn4 GND PULSE(1.65 3.3 1 100p 100p 1 2)
V_BP3 bp3 GND PULSE(1.65 3.3 1 100p 100p 1 2)
V_BN3 bn3 GND PULSE(1.65 3.3 1 100p 100p 1 2)
V_BP2 bp2 GND PULSE(1.65 3.3 1 100p 100p 1 2)
V_BN2 bn2 GND PULSE(1.65 3.3 1 100p 100p 1 2)
V_BP1 bp1 GND PULSE(1.65 3.3 1 100p 100p 1 2)
V_BN1 bn1 GND PULSE(1.65 3.3 1 100p 100p 1 2)
V_BP0 bp0 GND PULSE(1.65 3.3 1 100p 100p 1 2)
V_BN0 bn0 GND PULSE(1.65 3.3 1 100p 100p 1 2)
V_BPD bpd GND PULSE(1.65 3.3 1 100p 100p 1 2)
V_BND bnd GND PULSE(1.65 3.3 1 100p 100p 1 2)
V_INP ainp GND dc {VCM+VDIFF/2}
V_INN ainn GND dc {VCM-VDIFF/2}
V_VCM vcm GND dc {VCM}
V_SAMPLE sample GND PULSE(3.3 0 20n 100p 100p 1 2)
V_RSTF rstf GND PULSE(3.3 0 19n 100p 100p 1 2)
S_SP ainp vcp sample GND SWIDEAL
S_SN ainn vcn sample GND SWIDEAL
S_RP vcm vfp rstf GND SWIDEAL
S_RN vcm vfn rstf GND SWIDEAL
C_PFP vfp GND {CPF} m=1
C_PFN vfn GND {CPF} m=1
C_PXP vcp GND {CPX} m=1
C_PXN vcn GND {CPX} m=1
C_DBP vcp vfp {DCB} m=1
C_DBN vcn vfn {DCB} m=1
**** begin user architecture code

.include $::env(PDK_ROOT)/$::env(PDK)/libs.tech/ngspice/design.ngspice
.lib $::env(PDK_ROOT)/$::env(PDK)/libs.tech/ngspice/sm141064.ngspice typical
.lib $::env(PDK_ROOT)/$::env(PDK)/libs.tech/ngspice/sm141064.ngspice cap_mim
.lib $::env(PDK_ROOT)/$::env(PDK)/libs.tech/ngspice/sm141064.ngspice mimcap_typical



.param VDD=3.3 VCM=1.65 VREFP=3.3 VDIFF=0
.param CU='1.99e-3*25e-12+2.383e-10*20e-6'
* .temp = MIM model tnom (25 C): the PDK units then equal CU exactly, so the
* ideal sensitivity caps below are expressed in true Cu (tc1 = 14.6 ppm/K)
.temp 25
.param CPF_U=0 CPX_U=0 EPS_B=0
.param CPF='CPF_U*CU' CPX='CPX_U*CU' DCB='EPS_B*2*CU'
.model SWIDEAL SW VT=1.65 VH=0.05 RON=50 ROFF=1e12
* IDEAL behavioural switch: RON 50 ohm; ROFF 1e12 ohm represents the off-state
* leakage of a real 3.3 V switch (order of pA).  It is the only resistive path
* on the floating nodes besides the PDK MIM r_leak; no other resistors are added.
.options reltol=1e-9 abstol=1e-18 vntol=1e-12 method=gear
.save v(vcp) v(vcn) v(vfp) v(vfn) v(ainp) v(ainn)

.control
set noaskquit
set numdgt=12
shell rm -f split_cal_coef.txt split_cal_sar.txt split_cal_acq.txt
alterparam CPF_U=0
alterparam EPS_B=0
reset
* --- plate step coefficients ---
alter @v_bp9[pulse] = [ 1.65 3.3 30n 100p 100p 5n 2 ]
alter @v_bn9[pulse] = [ 1.65 3.3 30n 100p 100p 5n 2 ]
alter @v_bp8[pulse] = [ 1.65 3.3 40n 100p 100p 5n 2 ]
alter @v_bn8[pulse] = [ 1.65 3.3 40n 100p 100p 5n 2 ]
alter @v_bp7[pulse] = [ 1.65 3.3 50n 100p 100p 5n 2 ]
alter @v_bn7[pulse] = [ 1.65 3.3 50n 100p 100p 5n 2 ]
alter @v_bp6[pulse] = [ 1.65 3.3 60n 100p 100p 5n 2 ]
alter @v_bn6[pulse] = [ 1.65 3.3 60n 100p 100p 5n 2 ]
alter @v_bp5[pulse] = [ 1.65 3.3 70n 100p 100p 5n 2 ]
alter @v_bn5[pulse] = [ 1.65 3.3 70n 100p 100p 5n 2 ]
alter @v_bpr[pulse] = [ 1.65 3.3 80n 100p 100p 5n 2 ]
alter @v_bnr[pulse] = [ 1.65 3.3 80n 100p 100p 5n 2 ]
alter @v_bp4[pulse] = [ 1.65 3.3 90n 100p 100p 5n 2 ]
alter @v_bn4[pulse] = [ 1.65 3.3 90n 100p 100p 5n 2 ]
alter @v_bp3[pulse] = [ 1.65 3.3 100n 100p 100p 5n 2 ]
alter @v_bn3[pulse] = [ 1.65 3.3 100n 100p 100p 5n 2 ]
alter @v_bp2[pulse] = [ 1.65 3.3 110n 100p 100p 5n 2 ]
alter @v_bn2[pulse] = [ 1.65 3.3 110n 100p 100p 5n 2 ]
alter @v_bp1[pulse] = [ 1.65 3.3 120n 100p 100p 5n 2 ]
alter @v_bn1[pulse] = [ 1.65 3.3 120n 100p 100p 5n 2 ]
alter @v_bp0[pulse] = [ 1.65 3.3 130n 100p 100p 5n 2 ]
alter @v_bn0[pulse] = [ 1.65 3.3 130n 100p 100p 5n 2 ]
alter @v_bpd[pulse] = [ 1.65 3.3 140n 100p 100p 5n 2 ]
alter @v_bnd[pulse] = [ 1.65 3.3 140n 100p 100p 5n 2 ]
tran 20p 155n
let _m = time ge 29.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 29.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 29.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 29.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 34n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 34n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 34n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 34n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp9 0 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn9 0 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 39.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 39.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 39.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 39.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 44n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 44n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 44n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 44n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp8 0 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn8 0 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 49.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 49.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 49.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 49.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 54n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 54n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 54n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 54n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp7 0 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn7 0 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 59.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 59.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 59.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 59.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 64n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 64n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 64n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 64n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp6 0 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn6 0 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 69.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 69.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 69.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 69.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 74n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 74n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 74n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 74n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp5 0 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn5 0 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 79.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 79.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 79.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 79.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 84n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 84n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 84n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 84n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bpr 0 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bnr 0 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 89.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 89.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 89.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 89.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 94n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 94n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 94n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 94n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp4 0 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn4 0 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 99.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 99.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 99.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 99.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 104n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 104n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 104n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 104n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp3 0 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn3 0 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 109.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 109.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 109.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 109.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 114n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 114n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 114n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 114n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp2 0 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn2 0 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 119.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 119.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 119.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 119.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 124n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 124n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 124n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 124n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp1 0 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn1 0 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 129.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 129.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 129.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 129.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 134n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 134n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 134n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 134n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp0 0 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn0 0 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 139.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 139.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 139.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 139.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 144n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 144n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 144n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 144n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bpd 0 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bnd 0 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
alter @v_bp9[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn9[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp8[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn8[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp7[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn7[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp6[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn6[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp5[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn5[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bpr[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bnr[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp4[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn4[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp3[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn3[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp2[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn2[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp1[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn1[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp0[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn0[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bpd[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bnd[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
destroy all
alterparam CPF_U=0.25
alterparam EPS_B=0
reset
* --- plate step coefficients ---
alter @v_bp9[pulse] = [ 1.65 3.3 30n 100p 100p 5n 2 ]
alter @v_bn9[pulse] = [ 1.65 3.3 30n 100p 100p 5n 2 ]
alter @v_bp8[pulse] = [ 1.65 3.3 40n 100p 100p 5n 2 ]
alter @v_bn8[pulse] = [ 1.65 3.3 40n 100p 100p 5n 2 ]
alter @v_bp7[pulse] = [ 1.65 3.3 50n 100p 100p 5n 2 ]
alter @v_bn7[pulse] = [ 1.65 3.3 50n 100p 100p 5n 2 ]
alter @v_bp6[pulse] = [ 1.65 3.3 60n 100p 100p 5n 2 ]
alter @v_bn6[pulse] = [ 1.65 3.3 60n 100p 100p 5n 2 ]
alter @v_bp5[pulse] = [ 1.65 3.3 70n 100p 100p 5n 2 ]
alter @v_bn5[pulse] = [ 1.65 3.3 70n 100p 100p 5n 2 ]
alter @v_bpr[pulse] = [ 1.65 3.3 80n 100p 100p 5n 2 ]
alter @v_bnr[pulse] = [ 1.65 3.3 80n 100p 100p 5n 2 ]
alter @v_bp4[pulse] = [ 1.65 3.3 90n 100p 100p 5n 2 ]
alter @v_bn4[pulse] = [ 1.65 3.3 90n 100p 100p 5n 2 ]
alter @v_bp3[pulse] = [ 1.65 3.3 100n 100p 100p 5n 2 ]
alter @v_bn3[pulse] = [ 1.65 3.3 100n 100p 100p 5n 2 ]
alter @v_bp2[pulse] = [ 1.65 3.3 110n 100p 100p 5n 2 ]
alter @v_bn2[pulse] = [ 1.65 3.3 110n 100p 100p 5n 2 ]
alter @v_bp1[pulse] = [ 1.65 3.3 120n 100p 100p 5n 2 ]
alter @v_bn1[pulse] = [ 1.65 3.3 120n 100p 100p 5n 2 ]
alter @v_bp0[pulse] = [ 1.65 3.3 130n 100p 100p 5n 2 ]
alter @v_bn0[pulse] = [ 1.65 3.3 130n 100p 100p 5n 2 ]
alter @v_bpd[pulse] = [ 1.65 3.3 140n 100p 100p 5n 2 ]
alter @v_bnd[pulse] = [ 1.65 3.3 140n 100p 100p 5n 2 ]
tran 20p 155n
let _m = time ge 29.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 29.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 29.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 29.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 34n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 34n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 34n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 34n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp9 0.25 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn9 0.25 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 39.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 39.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 39.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 39.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 44n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 44n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 44n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 44n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp8 0.25 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn8 0.25 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 49.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 49.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 49.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 49.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 54n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 54n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 54n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 54n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp7 0.25 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn7 0.25 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 59.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 59.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 59.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 59.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 64n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 64n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 64n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 64n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp6 0.25 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn6 0.25 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 69.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 69.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 69.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 69.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 74n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 74n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 74n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 74n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp5 0.25 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn5 0.25 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 79.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 79.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 79.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 79.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 84n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 84n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 84n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 84n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bpr 0.25 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bnr 0.25 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 89.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 89.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 89.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 89.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 94n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 94n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 94n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 94n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp4 0.25 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn4 0.25 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 99.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 99.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 99.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 99.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 104n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 104n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 104n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 104n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp3 0.25 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn3 0.25 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 109.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 109.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 109.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 109.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 114n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 114n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 114n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 114n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp2 0.25 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn2 0.25 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 119.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 119.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 119.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 119.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 124n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 124n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 124n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 124n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp1 0.25 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn1 0.25 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 129.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 129.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 129.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 129.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 134n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 134n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 134n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 134n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp0 0.25 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn0 0.25 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 139.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 139.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 139.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 139.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 144n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 144n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 144n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 144n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bpd 0.25 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bnd 0.25 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
alter @v_bp9[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn9[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp8[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn8[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp7[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn7[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp6[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn6[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp5[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn5[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bpr[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bnr[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp4[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn4[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp3[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn3[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp2[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn2[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp1[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn1[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp0[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn0[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bpd[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bnd[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
destroy all
alterparam CPF_U=1.0
alterparam EPS_B=0
reset
* --- plate step coefficients ---
alter @v_bp9[pulse] = [ 1.65 3.3 30n 100p 100p 5n 2 ]
alter @v_bn9[pulse] = [ 1.65 3.3 30n 100p 100p 5n 2 ]
alter @v_bp8[pulse] = [ 1.65 3.3 40n 100p 100p 5n 2 ]
alter @v_bn8[pulse] = [ 1.65 3.3 40n 100p 100p 5n 2 ]
alter @v_bp7[pulse] = [ 1.65 3.3 50n 100p 100p 5n 2 ]
alter @v_bn7[pulse] = [ 1.65 3.3 50n 100p 100p 5n 2 ]
alter @v_bp6[pulse] = [ 1.65 3.3 60n 100p 100p 5n 2 ]
alter @v_bn6[pulse] = [ 1.65 3.3 60n 100p 100p 5n 2 ]
alter @v_bp5[pulse] = [ 1.65 3.3 70n 100p 100p 5n 2 ]
alter @v_bn5[pulse] = [ 1.65 3.3 70n 100p 100p 5n 2 ]
alter @v_bpr[pulse] = [ 1.65 3.3 80n 100p 100p 5n 2 ]
alter @v_bnr[pulse] = [ 1.65 3.3 80n 100p 100p 5n 2 ]
alter @v_bp4[pulse] = [ 1.65 3.3 90n 100p 100p 5n 2 ]
alter @v_bn4[pulse] = [ 1.65 3.3 90n 100p 100p 5n 2 ]
alter @v_bp3[pulse] = [ 1.65 3.3 100n 100p 100p 5n 2 ]
alter @v_bn3[pulse] = [ 1.65 3.3 100n 100p 100p 5n 2 ]
alter @v_bp2[pulse] = [ 1.65 3.3 110n 100p 100p 5n 2 ]
alter @v_bn2[pulse] = [ 1.65 3.3 110n 100p 100p 5n 2 ]
alter @v_bp1[pulse] = [ 1.65 3.3 120n 100p 100p 5n 2 ]
alter @v_bn1[pulse] = [ 1.65 3.3 120n 100p 100p 5n 2 ]
alter @v_bp0[pulse] = [ 1.65 3.3 130n 100p 100p 5n 2 ]
alter @v_bn0[pulse] = [ 1.65 3.3 130n 100p 100p 5n 2 ]
alter @v_bpd[pulse] = [ 1.65 3.3 140n 100p 100p 5n 2 ]
alter @v_bnd[pulse] = [ 1.65 3.3 140n 100p 100p 5n 2 ]
tran 20p 155n
let _m = time ge 29.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 29.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 29.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 29.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 34n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 34n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 34n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 34n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp9 1.0 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn9 1.0 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 39.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 39.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 39.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 39.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 44n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 44n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 44n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 44n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp8 1.0 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn8 1.0 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 49.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 49.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 49.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 49.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 54n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 54n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 54n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 54n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp7 1.0 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn7 1.0 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 59.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 59.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 59.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 59.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 64n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 64n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 64n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 64n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp6 1.0 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn6 1.0 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 69.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 69.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 69.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 69.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 74n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 74n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 74n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 74n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp5 1.0 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn5 1.0 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 79.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 79.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 79.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 79.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 84n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 84n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 84n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 84n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bpr 1.0 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bnr 1.0 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 89.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 89.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 89.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 89.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 94n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 94n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 94n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 94n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp4 1.0 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn4 1.0 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 99.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 99.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 99.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 99.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 104n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 104n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 104n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 104n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp3 1.0 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn3 1.0 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 109.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 109.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 109.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 109.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 114n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 114n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 114n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 114n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp2 1.0 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn2 1.0 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 119.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 119.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 119.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 119.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 124n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 124n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 124n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 124n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp1 1.0 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn1 1.0 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 129.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 129.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 129.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 129.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 134n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 134n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 134n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 134n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp0 1.0 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn0 1.0 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 139.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 139.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 139.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 139.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 144n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 144n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 144n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 144n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bpd 1.0 0 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bnd 1.0 0 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
alter @v_bp9[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn9[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp8[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn8[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp7[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn7[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp6[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn6[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp5[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn5[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bpr[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bnr[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp4[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn4[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp3[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn3[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp2[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn2[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp1[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn1[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp0[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn0[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bpd[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bnd[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
destroy all
alterparam CPF_U=0
alterparam EPS_B=0.05
reset
* --- plate step coefficients ---
alter @v_bp9[pulse] = [ 1.65 3.3 30n 100p 100p 5n 2 ]
alter @v_bn9[pulse] = [ 1.65 3.3 30n 100p 100p 5n 2 ]
alter @v_bp8[pulse] = [ 1.65 3.3 40n 100p 100p 5n 2 ]
alter @v_bn8[pulse] = [ 1.65 3.3 40n 100p 100p 5n 2 ]
alter @v_bp7[pulse] = [ 1.65 3.3 50n 100p 100p 5n 2 ]
alter @v_bn7[pulse] = [ 1.65 3.3 50n 100p 100p 5n 2 ]
alter @v_bp6[pulse] = [ 1.65 3.3 60n 100p 100p 5n 2 ]
alter @v_bn6[pulse] = [ 1.65 3.3 60n 100p 100p 5n 2 ]
alter @v_bp5[pulse] = [ 1.65 3.3 70n 100p 100p 5n 2 ]
alter @v_bn5[pulse] = [ 1.65 3.3 70n 100p 100p 5n 2 ]
alter @v_bpr[pulse] = [ 1.65 3.3 80n 100p 100p 5n 2 ]
alter @v_bnr[pulse] = [ 1.65 3.3 80n 100p 100p 5n 2 ]
alter @v_bp4[pulse] = [ 1.65 3.3 90n 100p 100p 5n 2 ]
alter @v_bn4[pulse] = [ 1.65 3.3 90n 100p 100p 5n 2 ]
alter @v_bp3[pulse] = [ 1.65 3.3 100n 100p 100p 5n 2 ]
alter @v_bn3[pulse] = [ 1.65 3.3 100n 100p 100p 5n 2 ]
alter @v_bp2[pulse] = [ 1.65 3.3 110n 100p 100p 5n 2 ]
alter @v_bn2[pulse] = [ 1.65 3.3 110n 100p 100p 5n 2 ]
alter @v_bp1[pulse] = [ 1.65 3.3 120n 100p 100p 5n 2 ]
alter @v_bn1[pulse] = [ 1.65 3.3 120n 100p 100p 5n 2 ]
alter @v_bp0[pulse] = [ 1.65 3.3 130n 100p 100p 5n 2 ]
alter @v_bn0[pulse] = [ 1.65 3.3 130n 100p 100p 5n 2 ]
alter @v_bpd[pulse] = [ 1.65 3.3 140n 100p 100p 5n 2 ]
alter @v_bnd[pulse] = [ 1.65 3.3 140n 100p 100p 5n 2 ]
tran 20p 155n
let _m = time ge 29.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 29.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 29.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 29.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 34n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 34n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 34n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 34n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp9 0 0.05 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn9 0 0.05 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 39.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 39.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 39.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 39.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 44n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 44n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 44n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 44n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp8 0 0.05 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn8 0 0.05 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 49.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 49.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 49.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 49.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 54n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 54n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 54n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 54n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp7 0 0.05 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn7 0 0.05 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 59.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 59.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 59.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 59.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 64n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 64n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 64n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 64n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp6 0 0.05 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn6 0 0.05 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 69.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 69.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 69.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 69.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 74n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 74n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 74n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 74n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp5 0 0.05 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn5 0 0.05 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 79.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 79.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 79.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 79.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 84n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 84n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 84n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 84n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bpr 0 0.05 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bnr 0 0.05 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 89.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 89.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 89.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 89.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 94n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 94n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 94n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 94n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp4 0 0.05 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn4 0 0.05 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 99.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 99.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 99.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 99.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 104n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 104n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 104n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 104n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp3 0 0.05 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn3 0 0.05 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 109.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 109.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 109.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 109.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 114n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 114n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 114n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 114n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp2 0 0.05 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn2 0 0.05 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 119.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 119.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 119.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 119.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 124n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 124n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 124n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 124n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp1 0 0.05 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn1 0 0.05 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 129.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 129.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 129.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 129.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 134n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 134n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 134n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 134n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp0 0 0.05 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn0 0 0.05 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 139.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 139.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 139.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 139.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 144n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 144n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 144n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 144n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bpd 0 0.05 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bnd 0 0.05 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
alter @v_bp9[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn9[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp8[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn8[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp7[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn7[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp6[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn6[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp5[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn5[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bpr[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bnr[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp4[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn4[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp3[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn3[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp2[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn2[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp1[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn1[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp0[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn0[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bpd[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bnd[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
destroy all
alterparam CPF_U=0
alterparam EPS_B=-0.05
reset
* --- plate step coefficients ---
alter @v_bp9[pulse] = [ 1.65 3.3 30n 100p 100p 5n 2 ]
alter @v_bn9[pulse] = [ 1.65 3.3 30n 100p 100p 5n 2 ]
alter @v_bp8[pulse] = [ 1.65 3.3 40n 100p 100p 5n 2 ]
alter @v_bn8[pulse] = [ 1.65 3.3 40n 100p 100p 5n 2 ]
alter @v_bp7[pulse] = [ 1.65 3.3 50n 100p 100p 5n 2 ]
alter @v_bn7[pulse] = [ 1.65 3.3 50n 100p 100p 5n 2 ]
alter @v_bp6[pulse] = [ 1.65 3.3 60n 100p 100p 5n 2 ]
alter @v_bn6[pulse] = [ 1.65 3.3 60n 100p 100p 5n 2 ]
alter @v_bp5[pulse] = [ 1.65 3.3 70n 100p 100p 5n 2 ]
alter @v_bn5[pulse] = [ 1.65 3.3 70n 100p 100p 5n 2 ]
alter @v_bpr[pulse] = [ 1.65 3.3 80n 100p 100p 5n 2 ]
alter @v_bnr[pulse] = [ 1.65 3.3 80n 100p 100p 5n 2 ]
alter @v_bp4[pulse] = [ 1.65 3.3 90n 100p 100p 5n 2 ]
alter @v_bn4[pulse] = [ 1.65 3.3 90n 100p 100p 5n 2 ]
alter @v_bp3[pulse] = [ 1.65 3.3 100n 100p 100p 5n 2 ]
alter @v_bn3[pulse] = [ 1.65 3.3 100n 100p 100p 5n 2 ]
alter @v_bp2[pulse] = [ 1.65 3.3 110n 100p 100p 5n 2 ]
alter @v_bn2[pulse] = [ 1.65 3.3 110n 100p 100p 5n 2 ]
alter @v_bp1[pulse] = [ 1.65 3.3 120n 100p 100p 5n 2 ]
alter @v_bn1[pulse] = [ 1.65 3.3 120n 100p 100p 5n 2 ]
alter @v_bp0[pulse] = [ 1.65 3.3 130n 100p 100p 5n 2 ]
alter @v_bn0[pulse] = [ 1.65 3.3 130n 100p 100p 5n 2 ]
alter @v_bpd[pulse] = [ 1.65 3.3 140n 100p 100p 5n 2 ]
alter @v_bnd[pulse] = [ 1.65 3.3 140n 100p 100p 5n 2 ]
tran 20p 155n
let _m = time ge 29.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 29.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 29.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 29.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 34n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 34n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 34n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 34n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp9 0 -0.05 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn9 0 -0.05 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 39.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 39.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 39.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 39.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 44n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 44n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 44n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 44n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp8 0 -0.05 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn8 0 -0.05 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 49.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 49.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 49.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 49.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 54n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 54n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 54n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 54n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp7 0 -0.05 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn7 0 -0.05 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 59.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 59.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 59.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 59.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 64n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 64n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 64n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 64n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp6 0 -0.05 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn6 0 -0.05 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 69.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 69.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 69.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 69.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 74n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 74n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 74n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 74n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp5 0 -0.05 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn5 0 -0.05 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 79.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 79.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 79.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 79.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 84n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 84n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 84n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 84n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bpr 0 -0.05 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bnr 0 -0.05 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 89.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 89.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 89.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 89.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 94n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 94n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 94n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 94n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp4 0 -0.05 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn4 0 -0.05 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 99.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 99.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 99.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 99.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 104n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 104n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 104n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 104n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp3 0 -0.05 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn3 0 -0.05 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 109.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 109.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 109.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 109.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 114n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 114n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 114n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 114n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp2 0 -0.05 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn2 0 -0.05 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 119.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 119.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 119.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 119.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 124n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 124n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 124n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 124n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp1 0 -0.05 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn1 0 -0.05 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 129.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 129.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 129.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 129.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 134n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 134n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 134n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 134n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bp0 0 -0.05 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bn0 0 -0.05 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
let _m = time ge 139.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a0 = v(vcp)[_i]
let _m = time ge 139.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f0 = v(vfp)[_i]
let _m = time ge 139.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c0 = v(vcn)[_i]
let _m = time ge 139.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g0 = v(vfn)[_i]
let _m = time ge 144n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let a1 = v(vcp)[_i]
let _m = time ge 144n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let f1 = v(vfp)[_i]
let _m = time ge 144n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let c1 = v(vcn)[_i]
let _m = time ge 144n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let g1 = v(vfn)[_i]
let kp = (a1-a0)/1.65
let kfp = (f1-f0)/1.65
let kn = (c1-c0)/1.65
let kfn = (g1-g0)/1.65
echo COEF bpd 0 -0.05 >> split_cal_coef.txt
print kp >> split_cal_coef.txt
print kfp >> split_cal_coef.txt
echo COEF bnd 0 -0.05 >> split_cal_coef.txt
print kn >> split_cal_coef.txt
print kfn >> split_cal_coef.txt
alter @v_bp9[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn9[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp8[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn8[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp7[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn7[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp6[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn6[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp5[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn5[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bpr[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bnr[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp4[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn4[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp3[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn3[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp2[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn2[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp1[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn1[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bp0[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bn0[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bpd[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
alter @v_bnd[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
destroy all
alterparam CPF_U=0
alterparam EPS_B=0
reset
* --- acquisition, fine-node reset and charge retention ---
alterparam VDIFF=0.8
reset
tran 50p 2.05u
let _m = time ge 18n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let ip18 = v(ainp)[_i]
let _m = time ge 18n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let in18 = v(ainn)[_i]
let _m = time ge 18n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let vcp18 = v(vcp)[_i]
let _m = time ge 18n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let vcn18 = v(vcn)[_i]
let _m = time ge 18.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let vfp18 = v(vfp)[_i]
let _m = time ge 18.5n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let vfn18 = v(vfn)[_i]
let _m = time ge 21n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let vcp21 = v(vcp)[_i]
let _m = time ge 21n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let vcn21 = v(vcn)[_i]
let _m = time ge 21n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let vfp21 = v(vfp)[_i]
let _m = time ge 21n
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let vfn21 = v(vfn)[_i]
let _m = time ge 2.02u
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let vcp2u = v(vcp)[_i]
let _m = time ge 2.02u
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let vcn2u = v(vcn)[_i]
let _m = time ge 2.02u
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let vfp2u = v(vfp)[_i]
let _m = time ge 2.02u
let _i = floor(length(time) - mean(_m)*length(_m) + 0.5)
let vfn2u = v(vfn)[_i]
let track_err_18n = (vcp18-vcn18) - (ip18-in18)
let hold_21n = vcp21-vcn21
let hold_2u = vcp2u-vcn2u
let droop_2us = hold_2u-hold_21n
let vfp_drift_2us = vfp2u-vfp21
let vfn_drift_2us = vfn2u-vfn21
echo ACQ VDIFF=0.8 > split_cal_acq.txt
print track_err_18n vfp18 vfn18 hold_21n hold_2u droop_2us >> split_cal_acq.txt
print vcp21 vcn21 vfp21 vfn21 vfp_drift_2us vfn_drift_2us >> split_cal_acq.txt
write split_cal_acq.raw v(vcp) v(vcn) v(vfp) v(vfn) v(ainp) v(ainn)
destroy all
alterparam VDIFF=0
reset
* --- SPICE-in-the-loop monotonic SAR (ideal sign comparator) ---
foreach vin 0.000151794 0.000455382 -0.000455382 1.553914443 -1.553914443 1.563477461 -1.563477461
+ 1.649089236 -1.649089236 0.801016559 0.801927323 -0.801927323 -0.801016559 0.400280589 0.401191352 1.201752530
+ 1.202663293 -1.202663293 -1.201752530 0.049636615 0.050547378 -0.050547378 -0.049636615 0.096692732 0.097603496
+ -0.097603496 -0.096692732 0.098210672 0.099121435 0.146784729 0.147695492 -0.147695492 -0.146784729 0.047359706
+ 0.048270469 0.048877645 0.049788408 0.851108556 0.852019319 -0.852019319 -0.851108556 -1.288109614 -0.818187489
+ 0.936583717 0.255420607 -1.261749080 -0.207890892 -0.065124149 -1.057783579
  let vpp = 1.65 + $vin/2
  let vnn = 1.65 - $vin/2
  alter @v_inp[dc] = $&vpp
  alter @v_inn[dc] = $&vnn
  alter @v_bp9[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
  alter @v_bn9[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
  alter @v_bp8[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
  alter @v_bn8[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
  alter @v_bp7[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
  alter @v_bn7[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
  alter @v_bp6[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
  alter @v_bn6[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
  alter @v_bp5[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
  alter @v_bn5[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
  alter @v_bpr[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
  alter @v_bnr[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
  alter @v_bp4[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
  alter @v_bn4[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
  alter @v_bp3[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
  alter @v_bn3[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
  alter @v_bp2[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
  alter @v_bn2[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
  alter @v_bp1[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
  alter @v_bn1[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
  alter @v_bp0[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
  alter @v_bn0[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
  alter @v_bpd[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
  alter @v_bnd[pulse] = [ 1.65 3.3 1 100p 100p 1 2 ]
  tran 50p 24n
  let vdd = v(vcp)[length(v(vcp))-1] - v(vcn)[length(v(vcn))-1]
  if vdd > 0
    set b0 = 1
    alter @v_bn9[pulse] = [ 1.65 3.3 25n 100p 100p 1 2 ]
  else
    set b0 = 0
    alter @v_bp9[pulse] = [ 1.65 3.3 25n 100p 100p 1 2 ]
  end
  destroy all
  tran 50p 30n
  let vdd = v(vcp)[length(v(vcp))-1] - v(vcn)[length(v(vcn))-1]
  if vdd > 0
    set b1 = 1
    alter @v_bn8[pulse] = [ 1.65 3.3 31n 100p 100p 1 2 ]
  else
    set b1 = 0
    alter @v_bp8[pulse] = [ 1.65 3.3 31n 100p 100p 1 2 ]
  end
  destroy all
  tran 50p 36n
  let vdd = v(vcp)[length(v(vcp))-1] - v(vcn)[length(v(vcn))-1]
  if vdd > 0
    set b2 = 1
    alter @v_bn7[pulse] = [ 1.65 3.3 37n 100p 100p 1 2 ]
  else
    set b2 = 0
    alter @v_bp7[pulse] = [ 1.65 3.3 37n 100p 100p 1 2 ]
  end
  destroy all
  tran 50p 42n
  let vdd = v(vcp)[length(v(vcp))-1] - v(vcn)[length(v(vcn))-1]
  if vdd > 0
    set b3 = 1
    alter @v_bn6[pulse] = [ 1.65 3.3 43n 100p 100p 1 2 ]
  else
    set b3 = 0
    alter @v_bp6[pulse] = [ 1.65 3.3 43n 100p 100p 1 2 ]
  end
  destroy all
  tran 50p 48n
  let vdd = v(vcp)[length(v(vcp))-1] - v(vcn)[length(v(vcn))-1]
  if vdd > 0
    set b4 = 1
    alter @v_bn5[pulse] = [ 1.65 3.3 49n 100p 100p 1 2 ]
  else
    set b4 = 0
    alter @v_bp5[pulse] = [ 1.65 3.3 49n 100p 100p 1 2 ]
  end
  destroy all
  tran 50p 54n
  let vdd = v(vcp)[length(v(vcp))-1] - v(vcn)[length(v(vcn))-1]
  if vdd > 0
    set b5 = 1
    alter @v_bnr[pulse] = [ 1.65 3.3 55n 100p 100p 1 2 ]
  else
    set b5 = 0
    alter @v_bpr[pulse] = [ 1.65 3.3 55n 100p 100p 1 2 ]
  end
  destroy all
  tran 50p 60n
  let vdd = v(vcp)[length(v(vcp))-1] - v(vcn)[length(v(vcn))-1]
  if vdd > 0
    set b6 = 1
    alter @v_bn4[pulse] = [ 1.65 3.3 61n 100p 100p 1 2 ]
  else
    set b6 = 0
    alter @v_bp4[pulse] = [ 1.65 3.3 61n 100p 100p 1 2 ]
  end
  destroy all
  tran 50p 66n
  let vdd = v(vcp)[length(v(vcp))-1] - v(vcn)[length(v(vcn))-1]
  if vdd > 0
    set b7 = 1
    alter @v_bn3[pulse] = [ 1.65 3.3 67n 100p 100p 1 2 ]
  else
    set b7 = 0
    alter @v_bp3[pulse] = [ 1.65 3.3 67n 100p 100p 1 2 ]
  end
  destroy all
  tran 50p 72n
  let vdd = v(vcp)[length(v(vcp))-1] - v(vcn)[length(v(vcn))-1]
  if vdd > 0
    set b8 = 1
    alter @v_bn2[pulse] = [ 1.65 3.3 73n 100p 100p 1 2 ]
  else
    set b8 = 0
    alter @v_bp2[pulse] = [ 1.65 3.3 73n 100p 100p 1 2 ]
  end
  destroy all
  tran 50p 78n
  let vdd = v(vcp)[length(v(vcp))-1] - v(vcn)[length(v(vcn))-1]
  if vdd > 0
    set b9 = 1
    alter @v_bn1[pulse] = [ 1.65 3.3 79n 100p 100p 1 2 ]
  else
    set b9 = 0
    alter @v_bp1[pulse] = [ 1.65 3.3 79n 100p 100p 1 2 ]
  end
  destroy all
  tran 50p 84n
  let vdd = v(vcp)[length(v(vcp))-1] - v(vcn)[length(v(vcn))-1]
  if vdd > 0
    set b10 = 1
    alter @v_bn0[pulse] = [ 1.65 3.3 85n 100p 100p 1 2 ]
  else
    set b10 = 0
    alter @v_bp0[pulse] = [ 1.65 3.3 85n 100p 100p 1 2 ]
  end
  destroy all
  tran 50p 90n
  let vdd = v(vcp)[length(v(vcp))-1] - v(vcn)[length(v(vcn))-1]
  if vdd > 0
    set b11 = 1
  else
    set b11 = 0
  end
  destroy all
  echo SAR $vin $b0 $b1 $b2 $b3 $b4 $b5 $b6 $b7 $b8 $b9 $b10 $b11 >> split_cal_sar.txt
end
echo done
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
